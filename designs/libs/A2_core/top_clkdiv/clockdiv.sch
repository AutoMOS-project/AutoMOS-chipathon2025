v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {ipin.sym} 10 -40 0 0 {name=p1 lab=VDD}
C {ipin.sym} 10 -10 0 0 {name=p2 lab=VSS}
C {ipin.sym} 10 20 0 0 {name=p3 lab=clk}
C {opin.sym} 10 100 0 0 {name=p5 lab=outclkdiv2}
C {opin.sym} 10 130 0 0 {name=p6 lab=outclkdiv4}
C {opin.sym} 10 70 0 0 {name=p8 lab=outclkdiv1}
C {ipin.sym} -10 170 0 0 {name=p9 lab=rst_n}
