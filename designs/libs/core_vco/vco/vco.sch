v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 130 -20 130 0 {lab=SUB}
C {iopin.sym} 80 -200 3 0 {name=p1 lab=VDD}
C {iopin.sym} 80 0 1 0 {name=p2 lab=VSS}
C {iopin.sym} 130 0 1 0 {name=p3 lab=SUB}
C {noconn.sym} 130 -20 0 0 {name=l1}
C {iopin.sym} 20 -150 2 0 {name=p6 lab=IBIAS}
C {iopin.sym} 140 -120 0 0 {name=p4 lab=VOUT}
C {ipin.sym} 20 -90 0 0 {name=p5 lab=EN}
C {iopin.sym} 20 -120 2 0 {name=p7 lab=VIN}
