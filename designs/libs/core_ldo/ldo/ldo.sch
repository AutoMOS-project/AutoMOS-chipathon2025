v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 120 20 120 40 {lab=SUB}
C {iopin.sym} 90 -90 3 0 {name=p1 lab=VDD}
C {iopin.sym} 80 40 1 0 {name=p2 lab=VSS}
C {iopin.sym} 160 -60 0 0 {name=p3 lab=VOUT}
C {iopin.sym} 120 40 1 0 {name=p4 lab=SUB}
C {iopin.sym} 40 -80 2 0 {name=p5 lab=VREF}
C {iopin.sym} 40 -40 2 0 {name=p6 lab=IBIAS}
C {noconn.sym} 120 20 0 0 {name=l1}
C {iopin.sym} 160 -30 0 0 {name=p7 lab=VTEST}
C {ipin.sym} 40 0 0 0 {name=p8 lab=TEST_EN}
