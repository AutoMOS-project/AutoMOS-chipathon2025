v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_vco/vco/vco.sym} 70 -140 0 0 {name=I_vco}
C {lab_pin.sym} 130 -160 0 1 {name=p1 lab=VDD}
C {lab_pin.sym} 50 -60 0 0 {name=p2 lab=IBIAS}
C {lab_pin.sym} 230 -100 0 1 {name=p3 lab=VOUT}
C {lab_pin.sym} 50 -40 0 0 {name=p4 lab=EN}
C {lab_pin.sym} 150 0 1 1 {name=p5 lab=SUB}
C {lab_pin.sym} 130 0 1 1 {name=p6 lab=VSS}
C {lab_pin.sym} 50 -100 0 0 {name=p7 lab=VIN}
