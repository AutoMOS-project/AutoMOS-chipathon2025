v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 130 -20 130 0 {lab=SUB}
C {iopin.sym} 80 -200 3 0 {name=p1 lab=VDD}
C {iopin.sym} 80 0 1 0 {name=p2 lab=VSS}
C {iopin.sym} 130 0 1 0 {name=p3 lab=SUB}
C {iopin.sym} 30 -150 2 0 {name=p4 lab=VBG}
C {iopin.sym} 30 -110 2 0 {name=p5 lab=IPTAT_IN}
C {iopin.sym} 30 -70 2 0 {name=p6 lab=IZTC_IN}
C {iopin.sym} 220 -90 0 0 {name=p7 lab=VREF_1V}
C {iopin.sym} 220 -60 0 0 {name=p8 lab=VREF_0P5V}
C {iopin.sym} 220 -150 0 0 {name=p9 lab=IPTAT[2:0]
}
C {iopin.sym} 220 -120 0 0 {name=p10 lab=IZTC[2:0]
}
C {noconn.sym} 130 -20 0 0 {name=l1}
