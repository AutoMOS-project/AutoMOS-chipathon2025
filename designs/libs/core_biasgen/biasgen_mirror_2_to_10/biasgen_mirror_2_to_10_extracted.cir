* Extracted by KLayout with GF180MCU LVS runset on : 22/09/2025 01:28

.SUBCKT biasgen_mirror_2_to_10 VSS ENB Iout_2u_snk Iout_10u_snk EN VDD
+ Iout_10u_src SUB
M$1 VDD VDD VDD VDD pfet_05v0 L=0.8U W=2U AS=1.16P AD=1.16P PS=6.32U PD=6.32U
M$2 \$86 \$57 \$94 VDD pfet_05v0 L=0.8U W=2U AS=1.2P AD=1.2P PS=6.4U PD=6.4U
M$3 Iout_10u_src \$57 \$95 VDD pfet_05v0 L=0.8U W=10U AS=6P AD=6P PS=32U PD=32U
M$8 \$56 \$57 \$96 VDD pfet_05v0 L=0.8U W=2U AS=1.2P AD=1.2P PS=6.4U PD=6.4U
M$17 VDD EN \$57 \$115 pfet_05v0 L=0.5U W=1U AS=0.77P AD=0.77P PS=3.54U PD=3.54U
M$18 VDD VDD VDD VDD pfet_05v0 L=6U W=4U AS=2.32P AD=2.32P PS=12.64U PD=12.64U
M$19 VDD EN \$56 \$118 pfet_05v0 L=0.5U W=1U AS=0.77P AD=0.77P PS=3.54U PD=3.54U
M$20 \$57 \$57 VDD VDD pfet_05v0 L=6U W=2U AS=1.2P AD=1.2P PS=6.4U PD=6.4U
M$22 VDD VDD VDD VDD pfet_05v0 L=1.5U W=2U AS=1.16P AD=1.16P PS=6.32U PD=6.32U
M$23 \$94 \$56 VDD VDD pfet_05v0 L=1.5U W=2U AS=1.2P AD=1.2P PS=6.4U PD=6.4U
M$24 \$95 \$56 VDD VDD pfet_05v0 L=1.5U W=10U AS=6P AD=6P PS=32U PD=32U
M$29 \$96 \$56 VDD VDD pfet_05v0 L=1.5U W=2U AS=1.2P AD=1.2P PS=6.4U PD=6.4U
M$41 VSS VSS VSS SUB nfet_05v0 L=2U W=1U AS=0.58P AD=0.58P PS=4.32U PD=4.32U
M$42 \$12 \$9 VSS SUB nfet_05v0 L=2U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$43 \$13 \$9 VSS SUB nfet_05v0 L=2U W=5U AS=3P AD=3P PS=22U PD=22U
M$48 \$14 \$9 VSS SUB nfet_05v0 L=2U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$49 \$15 \$9 VSS SUB nfet_05v0 L=2U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$50 \$16 \$9 VSS SUB nfet_05v0 L=2U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$61 VSS ENB \$46 SUB nfet_05v0 L=0.6U W=2U AS=1.46P AD=1.46P PS=5.46U PD=5.46U
M$62 VSS ENB \$9 SUB nfet_05v0 L=0.6U W=2U AS=1.46P AD=1.46P PS=5.46U PD=5.46U
M$63 VSS VSS VSS SUB nfet_05v0 L=0.8U W=1U AS=0.58P AD=0.58P PS=4.32U PD=4.32U
M$64 Iout_2u_snk \$46 \$12 SUB nfet_05v0 L=0.8U W=1U AS=0.6P AD=0.6P PS=4.4U
+ PD=4.4U
M$65 Iout_10u_snk \$46 \$13 SUB nfet_05v0 L=0.8U W=5U AS=3P AD=3P PS=22U PD=22U
M$70 \$56 \$46 \$14 SUB nfet_05v0 L=0.8U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$71 \$57 \$46 \$15 SUB nfet_05v0 L=0.8U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$72 \$9 \$46 \$16 SUB nfet_05v0 L=0.8U W=1U AS=0.6P AD=0.6P PS=4.4U PD=4.4U
M$83 \$46 EN \$78 SUB nfet_05v0 L=0.6U W=2U AS=1.46P AD=1.46P PS=5.46U PD=5.46U
R$91 \$9 \$46 SUB 36000 ppolyf_u_1k_6p0 L=36U W=1U
.ENDS biasgen_mirror_2_to_10
