v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 220 -20 220 -0 {lab=SUB}
C {iopin.sym} 160 -240 3 0 {name=p1 lab=VDD}
C {iopin.sym} 160 0 1 0 {name=p2 lab=VSS}
C {iopin.sym} 220 0 1 0 {name=p3 lab=SUB}
C {iopin.sym} 320 -180 0 0 {name=p4 lab=VBG}
C {iopin.sym} 320 -130 0 0 {name=p5 lab=IPTAT}
C {iopin.sym} 320 -90 0 0 {name=p6 lab=IZTC}
C {noconn.sym} 220 -20 0 0 {name=l1}
