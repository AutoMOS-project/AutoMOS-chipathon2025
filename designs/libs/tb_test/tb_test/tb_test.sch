v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_test/test/test.sym} 60 -280 0 0 {name=I_test}
C {lab_pin.sym} 140 -300 0 1 {name=p1 lab=VDD}
C {lab_pin.sym} 40 -260 0 0 {name=p2 lab=IBIAS}
C {lab_pin.sym} 240 -240 0 1 {name=p3 lab=VOUT}
C {lab_pin.sym} 40 -60 0 0 {name=p4 lab=EN}
C {lab_pin.sym} 40 -40 0 0 {name=p5 lab=SEL[2:0]}
C {lab_pin.sym} 160 0 1 1 {name=p6 lab=SUB}
C {lab_pin.sym} 140 0 1 1 {name=p7 lab=VSS}
C {lab_pin.sym} 40 -240 0 0 {name=p8 lab=IN0}
C {lab_pin.sym} 40 -220 0 0 {name=p9 lab=IN1}
C {lab_pin.sym} 40 -200 0 0 {name=p10 lab=IN2}
C {lab_pin.sym} 40 -180 0 0 {name=p11 lab=IN3}
C {lab_pin.sym} 40 -160 0 0 {name=p12 lab=IN4}
C {lab_pin.sym} 40 -140 0 0 {name=p13 lab=IN5}
C {lab_pin.sym} 40 -120 0 0 {name=p14 lab=IN6}
C {lab_pin.sym} 40 -100 0 0 {name=p15 lab=IN7}
