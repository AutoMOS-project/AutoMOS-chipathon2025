v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_bandgap/bandgap/bandgap.sym} 50 -140 0 0 {name=I_bandgap}
C {lab_pin.sym} 110 -160 0 1 {name=p1 lab=VDD}
C {lab_pin.sym} 210 -100 0 1 {name=p2 lab=VBG}
C {lab_pin.sym} 210 -60 0 1 {name=p3 lab=IPTAT}
C {lab_pin.sym} 210 -40 0 1 {name=p4 lab=IZTC}
C {lab_pin.sym} 130 0 1 1 {name=p5 lab=SUB}
C {lab_pin.sym} 110 0 1 1 {name=p6 lab=VSS}
