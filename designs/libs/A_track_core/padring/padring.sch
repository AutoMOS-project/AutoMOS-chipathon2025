v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
L 3 4560 -8040 4560 -7160 {}
L 3 3280 -8050 3280 -7170 {}
L 3 760 -8030 760 -7150 {}
L 3 7650 -8040 7650 -7160 {}
L 3 40 -1660 920 -1660 {}
L 3 1800 -1020 1800 -140 {}
L 3 5720 -1020 5720 -140 {}
L 3 7470 -1700 8350 -1700 {}
L 3 7520 -4500 8400 -4500 {}
B 3 2990 -6980 5220 -5740 {fill=false}
B 3 1040 -4980 2280 -2750 {fill=false}
B 3 2640 -2310 4870 -1070 {fill=false}
B 3 5760 -1700 7360 -1060 {fill=false}
B 3 6200 -4220 7440 -1990 {fill=false}
B 3 6200 -6970 7440 -4740 {fill=false}
T {A1_top} 4110 -6540 1 0 2.8 2.8 {}
T {A2_top} 1840 -3860 2 0 2.8 2.8 {}
T {AXX_top} 3750 -1510 3 0 2.8 2.8 {}
T {A5_top} 6470 -1140 3 0 2.8 2.8 {}
T {A3_top} 7000 -3100 2 0 2.8 2.8 {}
T {A4_top} 7000 -5850 2 0 2.8 2.8 {}
T {LDO_EN} 6000 40 0 0 0.8 0.8 {}
N 720 -7300 7660 -7300 {lab=#net1
bus=true}
N 7030 -7780 7050 -7780 {lab=VDD_A1}
N 7050 -7780 7050 -7420 {lab=VDD_A1}
N 7030 -7740 7030 -7380 {lab=VDD_A1}
N 6770 -7740 6770 -7300 {lab=#net1}
N 6750 -7780 6770 -7780 {lab=VSS_A1}
N 6690 -7780 6710 -7780 {lab=VDD_A1}
N 6710 -7780 6710 -7420 {lab=VDD_A1}
N 6690 -7740 6690 -7380 {lab=VDD_A1}
N 6430 -7740 6430 -7300 {lab=#net1}
N 6410 -7780 6430 -7780 {lab=VSS_A1}
N 6350 -7780 6370 -7780 {lab=VDD_A1}
N 6370 -7780 6370 -7420 {lab=VDD_A1}
N 6350 -7740 6350 -7380 {lab=VDD_A1}
N 6090 -7740 6090 -7300 {lab=#net1}
N 6070 -7780 6090 -7780 {lab=VSS_A1}
N 6750 -7780 6750 -7340 {lab=VSS_A1}
N 6410 -7780 6410 -7340 {lab=VSS_A1}
N 6070 -7780 6070 -7340 {lab=VSS_A1}
N 5990 -7780 6010 -7780 {lab=VDD_A1}
N 6010 -7780 6010 -7420 {lab=VDD_A1}
N 5990 -7740 5990 -7380 {lab=VDD_A1}
N 5830 -7740 5830 -7300 {lab=#net1}
N 5810 -7780 5830 -7780 {lab=VSS_A1}
N 5810 -7780 5810 -7340 {lab=VSS_A1}
N 5390 -7780 5390 -7420 {lab=VDD_A1}
N 5370 -7740 5370 -7380 {lab=VDD_A1}
N 5210 -7740 5210 -7300 {lab=#net1}
N 5190 -7780 5190 -7340 {lab=VSS_A1}
N 240 -6440 600 -6440 {lab=AVDD_A2}
N 280 -6420 640 -6420 {lab=AVDD_A2}
N 280 -6260 720 -6260 {lab=#net1}
N 240 -6240 680 -6240 {lab=AVSS_A2}
N 5370 -7780 5390 -7780 {lab=VDD_A1}
N 5190 -7780 5210 -7780 {lab=VSS_A1}
N 240 -6440 240 -6420 {lab=AVDD_A2}
N 240 -6260 240 -6240 {lab=AVSS_A2}
N 7340 -7780 7360 -7780 {lab=VDD_A1}
N 7360 -7780 7360 -7420 {lab=VDD_A1}
N 7340 -7740 7340 -7380 {lab=VDD_A1}
N 7590 -7780 7610 -7780 {lab=VDD_A1}
N 7610 -7780 7610 -7420 {lab=VDD_A1}
N 7430 -7740 7430 -7300 {lab=#net1}
N 7410 -7780 7430 -7780 {lab=VSS_A1}
N 7410 -7780 7410 -7340 {lab=VSS_A1}
N 3320 -7340 4540 -7340 {lab=#net2
bus=true}
N 3320 -7380 4540 -7380 {lab=LDO_OUT
bus=true}
N 3320 -7420 4540 -7420 {lab=LDO_OUT
bus=true}
N 4480 -7780 4500 -7780 {lab=LDO_OUT}
N 4500 -7780 4500 -7420 {lab=LDO_OUT}
N 4320 -7740 4320 -7300 {lab=#net1}
N 4300 -7780 4300 -7340 {lab=#net2}
N 4300 -7780 4320 -7780 {lab=#net2}
N 4060 -7740 4060 -7300 {lab=#net1}
N 4040 -7780 4040 -7340 {lab=#net2}
N 4040 -7780 4060 -7780 {lab=#net2}
N 5710 -7780 5730 -7780 {lab=VDD_A1}
N 5730 -7780 5730 -7420 {lab=VDD_A1}
N 5710 -7740 5710 -7380 {lab=VDD_A1}
N 5450 -7740 5450 -7300 {lab=#net1}
N 5430 -7780 5450 -7780 {lab=VSS_A1}
N 5430 -7780 5430 -7340 {lab=VSS_A1}
N 5130 -7780 5150 -7780 {lab=VDD_A1}
N 5150 -7780 5150 -7420 {lab=VDD_A1}
N 5130 -7740 5130 -7380 {lab=VDD_A1}
N 4870 -7740 4870 -7300 {lab=#net1}
N 4850 -7780 4870 -7780 {lab=VSS_A1}
N 4850 -7780 4850 -7340 {lab=VSS_A1}
N 4220 -7780 4240 -7780 {lab=LDO_OUT}
N 4240 -7780 4240 -7420 {lab=LDO_OUT}
N 4220 -7740 4220 -7380 {lab=LDO_OUT}
N 3980 -7780 4000 -7780 {lab=LDO_OUT}
N 4000 -7780 4000 -7420 {lab=LDO_OUT}
N 3980 -7740 3980 -7380 {lab=LDO_OUT}
N 3720 -7740 3720 -7300 {lab=#net1}
N 3700 -7780 3720 -7780 {lab=#net2}
N 3700 -7780 3700 -7340 {lab=#net2}
N 3640 -7780 3660 -7780 {lab=LDO_OUT}
N 3660 -7780 3660 -7420 {lab=LDO_OUT}
N 3640 -7740 3640 -7380 {lab=LDO_OUT}
N 3380 -7740 3380 -7300 {lab=#net1}
N 3360 -7780 3380 -7780 {lab=#net2}
N 3360 -7780 3360 -7340 {lab=#net2}
N 3160 -7780 3180 -7780 {lab=VTEST}
N 3180 -7780 3180 -7420 {lab=VTEST}
N 3000 -7740 3000 -7300 {lab=#net1}
N 2980 -7780 3000 -7780 {lab=#net3}
N 2980 -7780 2980 -7340 {lab=#net3}
N 2920 -7780 2940 -7780 {lab=VTEST}
N 2940 -7780 2940 -7420 {lab=VTEST}
N 2920 -7740 2920 -7380 {lab=VTEST}
N 2660 -7740 2660 -7300 {lab=#net1}
N 2640 -7780 2660 -7780 {lab=#net3}
N 2640 -7780 2640 -7340 {lab=#net3}
N 2580 -7780 2600 -7780 {lab=VTEST}
N 2600 -7780 2600 -7420 {lab=VTEST}
N 2420 -7740 2420 -7300 {lab=#net1}
N 2400 -7780 2420 -7780 {lab=#net3}
N 2400 -7780 2400 -7340 {lab=#net3}
N 720 -7340 3280 -7340 {lab=#net3
bus=true}
N 720 -7380 3280 -7380 {lab=VTEST
bus=true}
N 720 -7420 3280 -7420 {lab=VTEST
bus=true}
N 2580 -7740 2580 -7380 {lab=VTEST}
N 2340 -7780 2360 -7780 {lab=VTEST}
N 2360 -7780 2360 -7420 {lab=VTEST}
N 2340 -7740 2340 -7380 {lab=VTEST}
N 2080 -7740 2080 -7300 {lab=#net1}
N 2060 -7780 2080 -7780 {lab=#net3}
N 2060 -7780 2060 -7340 {lab=#net3}
N 2000 -7780 2020 -7780 {lab=VTEST}
N 2020 -7780 2020 -7420 {lab=VTEST}
N 2000 -7740 2000 -7380 {lab=VTEST}
N 1740 -7740 1740 -7300 {lab=#net1}
N 1720 -7780 1740 -7780 {lab=#net3}
N 1720 -7780 1720 -7340 {lab=#net3}
N 1660 -7780 1680 -7780 {lab=VTEST}
N 1680 -7780 1680 -7420 {lab=VTEST}
N 1660 -7740 1660 -7380 {lab=VTEST}
N 1400 -7740 1400 -7300 {lab=#net1}
N 1380 -7780 1400 -7780 {lab=#net3}
N 1380 -7780 1380 -7340 {lab=#net3}
N 1320 -7780 1340 -7780 {lab=VTEST}
N 1340 -7780 1340 -7420 {lab=VTEST}
N 1320 -7740 1320 -7380 {lab=VTEST}
N 1060 -7740 1060 -7300 {lab=#net1}
N 1040 -7780 1060 -7780 {lab=#net3}
N 1040 -7780 1040 -7340 {lab=#net3}
N 980 -7780 1000 -7780 {lab=VTEST}
N 1000 -7780 1000 -7420 {lab=VTEST}
N 980 -7740 980 -7380 {lab=VTEST}
N 820 -7740 820 -7300 {lab=#net1}
N 800 -7780 820 -7780 {lab=#net3}
N 800 -7780 800 -7340 {lab=#net3}
N 7160 -7780 7180 -7780 {lab=VSS_A1}
N 7160 -7780 7160 -7340 {lab=VSS_A1}
N 7180 -7780 7180 -7620 {lab=VSS_A1}
N 7180 -7560 7180 -7300 {lab=#net1}
N 3160 -7470 3160 -7380 {lab=VTEST}
N 3160 -7590 3160 -7530 {lab=VTEST}
N 3160 -7590 3180 -7590 {lab=VTEST}
N 4480 -7470 4480 -7380 {lab=LDO_OUT}
N 4480 -7590 4480 -7530 {lab=LDO_OUT}
N 4480 -7590 4500 -7590 {lab=LDO_OUT}
N 7590 -7470 7590 -7380 {lab=VDD_A1}
N 7590 -7590 7590 -7530 {lab=VDD_A1}
N 7590 -7590 7610 -7590 {lab=VDD_A1}
N 240 -6710 240 -6690 {lab=AVDD_A2}
N 240 -6710 600 -6710 {lab=AVDD_A2}
N 280 -6690 640 -6690 {lab=AVDD_A2}
N 240 -6960 240 -6940 {lab=AVDD_A2}
N 240 -6960 600 -6960 {lab=AVDD_A2}
N 280 -6780 720 -6780 {lab=#net1}
N 240 -6780 240 -6760 {lab=AVSS_A2}
N 240 -6760 680 -6760 {lab=AVSS_A2}
N 240 -6530 240 -6510 {lab=AVSS_A2}
N 240 -6510 680 -6510 {lab=AVSS_A2}
N 240 -6530 400 -6530 {lab=AVSS_A2}
N 460 -6530 720 -6530 {lab=#net1}
N 550 -6940 640 -6940 {lab=AVDD_A2}
N 430 -6940 490 -6940 {lab=AVDD_A2}
N 430 -6960 430 -6940 {lab=AVDD_A2}
N 600 -7060 600 -1730 {lab=AVDD_A2
bus=true}
N 640 -7060 640 -1730 {lab=AVDD_A2
bus=true}
N 680 -7060 680 -1710 {lab=AVSS_A2
bus=true}
N 720 -7300 720 -880 {lab=#net1
bus=true}
N 240 -6180 600 -6180 {lab=AVDD_A2}
N 280 -6160 640 -6160 {lab=AVDD_A2}
N 280 -6000 720 -6000 {lab=#net1}
N 240 -5980 680 -5980 {lab=AVSS_A2}
N 240 -6180 240 -6160 {lab=AVDD_A2}
N 240 -6000 240 -5980 {lab=AVSS_A2}
N 240 -5920 600 -5920 {lab=AVDD_A2}
N 280 -5900 640 -5900 {lab=AVDD_A2}
N 280 -5740 720 -5740 {lab=#net1}
N 240 -5720 680 -5720 {lab=AVSS_A2}
N 240 -5920 240 -5900 {lab=AVDD_A2}
N 240 -5740 240 -5720 {lab=AVSS_A2}
N 240 -5660 600 -5660 {lab=AVDD_A2}
N 280 -5640 640 -5640 {lab=AVDD_A2}
N 280 -5480 720 -5480 {lab=#net1}
N 240 -5460 680 -5460 {lab=AVSS_A2}
N 240 -5660 240 -5640 {lab=AVDD_A2}
N 240 -5480 240 -5460 {lab=AVSS_A2}
N 240 -5400 600 -5400 {lab=AVDD_A2}
N 280 -5380 640 -5380 {lab=AVDD_A2}
N 280 -5220 720 -5220 {lab=#net1}
N 240 -5200 680 -5200 {lab=AVSS_A2}
N 240 -5400 240 -5380 {lab=AVDD_A2}
N 240 -5220 240 -5200 {lab=AVSS_A2}
N 240 -5140 600 -5140 {lab=AVDD_A2}
N 280 -5120 640 -5120 {lab=AVDD_A2}
N 280 -4960 720 -4960 {lab=#net1}
N 240 -4940 680 -4940 {lab=AVSS_A2}
N 240 -5140 240 -5120 {lab=AVDD_A2}
N 240 -4960 240 -4940 {lab=AVSS_A2}
N 240 -4880 600 -4880 {lab=AVDD_A2}
N 280 -4860 640 -4860 {lab=AVDD_A2}
N 280 -4700 720 -4700 {lab=#net1}
N 240 -4680 680 -4680 {lab=AVSS_A2}
N 240 -4880 240 -4860 {lab=AVDD_A2}
N 240 -4700 240 -4680 {lab=AVSS_A2}
N 240 -4620 600 -4620 {lab=AVDD_A2}
N 280 -4600 640 -4600 {lab=AVDD_A2}
N 280 -4440 720 -4440 {lab=#net1}
N 240 -4420 680 -4420 {lab=AVSS_A2}
N 240 -4620 240 -4600 {lab=AVDD_A2}
N 240 -4440 240 -4420 {lab=AVSS_A2}
N 240 -4360 600 -4360 {lab=AVDD_A2}
N 280 -4340 640 -4340 {lab=AVDD_A2}
N 280 -4180 720 -4180 {lab=#net1}
N 240 -4160 680 -4160 {lab=AVSS_A2}
N 240 -4360 240 -4340 {lab=AVDD_A2}
N 240 -4180 240 -4160 {lab=AVSS_A2}
N 240 -4100 600 -4100 {lab=AVDD_A2}
N 280 -4080 640 -4080 {lab=AVDD_A2}
N 280 -3920 720 -3920 {lab=#net1}
N 240 -3900 680 -3900 {lab=AVSS_A2}
N 240 -4100 240 -4080 {lab=AVDD_A2}
N 240 -3920 240 -3900 {lab=AVSS_A2}
N 240 -3840 600 -3840 {lab=AVDD_A2}
N 280 -3820 640 -3820 {lab=AVDD_A2}
N 280 -3660 720 -3660 {lab=#net1}
N 240 -3640 680 -3640 {lab=AVSS_A2}
N 240 -3840 240 -3820 {lab=AVDD_A2}
N 240 -3660 240 -3640 {lab=AVSS_A2}
N 240 -3580 600 -3580 {lab=AVDD_A2}
N 280 -3560 640 -3560 {lab=AVDD_A2}
N 280 -3400 720 -3400 {lab=#net1}
N 240 -3380 680 -3380 {lab=AVSS_A2}
N 240 -3580 240 -3560 {lab=AVDD_A2}
N 240 -3400 240 -3380 {lab=AVSS_A2}
N 240 -3320 600 -3320 {lab=AVDD_A2}
N 280 -3300 640 -3300 {lab=AVDD_A2}
N 280 -3140 720 -3140 {lab=#net1}
N 240 -3120 680 -3120 {lab=AVSS_A2}
N 240 -3320 240 -3300 {lab=AVDD_A2}
N 240 -3140 240 -3120 {lab=AVSS_A2}
N 240 -3060 600 -3060 {lab=AVDD_A2}
N 280 -3040 640 -3040 {lab=AVDD_A2}
N 280 -2880 720 -2880 {lab=#net1}
N 240 -2860 680 -2860 {lab=AVSS_A2}
N 240 -3060 240 -3040 {lab=AVDD_A2}
N 240 -2880 240 -2860 {lab=AVSS_A2}
N 240 -2800 600 -2800 {lab=AVDD_A2}
N 280 -2780 640 -2780 {lab=AVDD_A2}
N 280 -2620 720 -2620 {lab=#net1}
N 240 -2600 680 -2600 {lab=AVSS_A2}
N 240 -2800 240 -2780 {lab=AVDD_A2}
N 240 -2620 240 -2600 {lab=AVSS_A2}
N 240 -2540 600 -2540 {lab=AVDD_A2}
N 280 -2520 640 -2520 {lab=AVDD_A2}
N 280 -2360 720 -2360 {lab=#net1}
N 240 -2340 680 -2340 {lab=AVSS_A2}
N 240 -2540 240 -2520 {lab=AVDD_A2}
N 240 -2360 240 -2340 {lab=AVSS_A2}
N 240 -2280 600 -2280 {lab=AVDD_A2}
N 280 -2260 640 -2260 {lab=AVDD_A2}
N 280 -2100 720 -2100 {lab=#net1}
N 240 -2080 680 -2080 {lab=AVSS_A2}
N 240 -2280 240 -2260 {lab=AVDD_A2}
N 240 -2100 240 -2080 {lab=AVSS_A2}
N 240 -2020 600 -2020 {lab=AVDD_A2}
N 280 -2000 640 -2000 {lab=AVDD_A2}
N 280 -1840 720 -1840 {lab=#net1}
N 240 -1820 680 -1820 {lab=AVSS_A2}
N 240 -2020 240 -2000 {lab=AVDD_A2}
N 240 -1840 240 -1820 {lab=AVSS_A2}
N 240 -1600 240 -1580 {lab=VDD_A2}
N 240 -1600 600 -1600 {lab=VDD_A2}
N 280 -1420 720 -1420 {lab=#net1}
N 240 -1420 240 -1400 {lab=VSS_A2}
N 240 -1400 680 -1400 {lab=VSS_A2}
N 550 -1580 640 -1580 {lab=VDD_A2}
N 430 -1580 490 -1580 {lab=VDD_A2}
N 430 -1600 430 -1580 {lab=VDD_A2}
N 240 -1340 240 -1320 {lab=VDD_A2}
N 240 -1340 600 -1340 {lab=VDD_A2}
N 280 -1320 640 -1320 {lab=VDD_A2}
N 280 -1060 720 -1060 {lab=#net1}
N 240 -1060 240 -1040 {lab=VSS_A2}
N 240 -1040 680 -1040 {lab=VSS_A2}
N 1100 -400 1120 -400 {lab=VDD_A2}
N 1100 -760 1100 -400 {lab=VDD_A2}
N 1120 -800 1120 -440 {lab=VDD_A2}
N 1280 -400 1300 -400 {lab=VSS_A2}
N 1300 -840 1300 -400 {lab=VSS_A2}
N 1280 -560 1280 -400 {lab=VSS_A2}
N 1280 -880 1280 -620 {lab=#net1}
N 680 -1620 680 -840 {lab=VSS_A2
bus=true}
N 680 -840 1760 -840 {lab=VSS_A2
bus=true}
N 640 -1620 640 -800 {lab=VDD_A2
bus=true}
N 640 -800 1760 -800 {lab=VDD_A2
bus=true}
N 600 -1620 600 -760 {lab=VDD_A2
bus=true}
N 600 -760 1760 -760 {lab=VDD_A2
bus=true}
N 1360 -400 1380 -400 {lab=VDD_A2}
N 1360 -760 1360 -400 {lab=VDD_A2}
N 1380 -800 1380 -440 {lab=VDD_A2}
N 1640 -880 1640 -440 {lab=#net1}
N 1640 -400 1660 -400 {lab=VSS_A2}
N 1660 -840 1660 -400 {lab=VSS_A2}
N 7780 -6680 8140 -6680 {lab=VDD_A4}
N 7740 -6660 8100 -6660 {lab=VDD_A4}
N 7660 -6500 8100 -6500 {lab=#net1}
N 7700 -6480 8140 -6480 {lab=VSS_A4}
N 8140 -6680 8140 -6660 {lab=VDD_A4}
N 8140 -6500 8140 -6480 {lab=VSS_A4}
N 8140 -5020 8140 -5000 {lab=VDD_A4}
N 7780 -5020 8140 -5020 {lab=VDD_A4}
N 7740 -5000 8100 -5000 {lab=VDD_A4}
N 8140 -4750 8140 -4730 {lab=VDD_A4}
N 7780 -4750 8140 -4750 {lab=VDD_A4}
N 7660 -4570 8100 -4570 {lab=#net1}
N 8140 -4570 8140 -4550 {lab=VSS_A4}
N 7700 -4550 8140 -4550 {lab=VSS_A4}
N 8140 -4840 8140 -4820 {lab=VSS_A4}
N 7700 -4820 8140 -4820 {lab=VSS_A4}
N 7980 -4840 8140 -4840 {lab=VSS_A4}
N 7660 -4840 7920 -4840 {lab=#net1}
N 7740 -4730 7830 -4730 {lab=VDD_A4}
N 7890 -4730 7950 -4730 {lab=VDD_A4}
N 7950 -4750 7950 -4730 {lab=VDD_A4}
N 7780 -7200 7780 -4700 {lab=VDD_A4
bus=true}
N 7740 -7180 7740 -4700 {lab=VDD_A4
bus=true}
N 7700 -7140 7700 -4520 {lab=VSS_A4
bus=true}
N 7780 -6420 8140 -6420 {lab=VDD_A4}
N 7740 -6400 8100 -6400 {lab=VDD_A4}
N 7660 -6240 8100 -6240 {lab=#net1}
N 7700 -6220 8140 -6220 {lab=VSS_A4}
N 8140 -6420 8140 -6400 {lab=VDD_A4}
N 8140 -6240 8140 -6220 {lab=VSS_A4}
N 7780 -6160 8140 -6160 {lab=VDD_A4}
N 7740 -6140 8100 -6140 {lab=VDD_A4}
N 7660 -5980 8100 -5980 {lab=#net1}
N 7700 -5960 8140 -5960 {lab=VSS_A4}
N 8140 -6160 8140 -6140 {lab=VDD_A4}
N 8140 -5980 8140 -5960 {lab=VSS_A4}
N 7780 -5900 8140 -5900 {lab=VDD_A4}
N 7740 -5880 8100 -5880 {lab=VDD_A4}
N 7660 -5720 8100 -5720 {lab=#net1}
N 7700 -5700 8140 -5700 {lab=VSS_A4}
N 8140 -5900 8140 -5880 {lab=VDD_A4}
N 8140 -5720 8140 -5700 {lab=VSS_A4}
N 7780 -5640 8140 -5640 {lab=VDD_A4}
N 7740 -5620 8100 -5620 {lab=VDD_A4}
N 7660 -5460 8100 -5460 {lab=#net1}
N 7700 -5440 8140 -5440 {lab=VSS_A4}
N 8140 -5640 8140 -5620 {lab=VDD_A4}
N 8140 -5460 8140 -5440 {lab=VSS_A4}
N 7780 -3400 8140 -3400 {lab=VDD3V3_A3}
N 7740 -3380 8100 -3380 {lab=VDD3V3_A3}
N 7660 -3120 8100 -3120 {lab=#net1}
N 7700 -3100 8140 -3100 {lab=VSS_1_A3}
N 8140 -3400 8140 -3380 {lab=VDD3V3_A3}
N 8140 -3120 8140 -3100 {lab=VSS_1_A3}
N 7780 -3920 8140 -3920 {lab=VDD3V3_A3}
N 7740 -3900 8100 -3900 {lab=VDD3V3_A3}
N 7660 -3740 8100 -3740 {lab=#net1}
N 7700 -3720 8140 -3720 {lab=VSS_1_A3}
N 8140 -3920 8140 -3900 {lab=VDD3V3_A3}
N 8140 -3740 8140 -3720 {lab=VSS_1_A3}
N 7780 -3660 8140 -3660 {lab=VDD3V3_A3}
N 7740 -3640 8100 -3640 {lab=VDD3V3_A3}
N 7660 -3480 8100 -3480 {lab=#net1}
N 7700 -3460 8140 -3460 {lab=VSS_1_A3}
N 8140 -3660 8140 -3640 {lab=VDD3V3_A3}
N 8140 -3480 8140 -3460 {lab=VSS_1_A3}
N 7780 -3040 8140 -3040 {lab=VDD3V3_A3}
N 7740 -3020 8100 -3020 {lab=VDD3V3_A3}
N 7660 -2860 8100 -2860 {lab=#net1}
N 7700 -2840 8140 -2840 {lab=VSS_1_A3}
N 8140 -3040 8140 -3020 {lab=VDD3V3_A3}
N 8140 -2860 8140 -2840 {lab=VSS_1_A3}
N 7780 -2780 8140 -2780 {lab=VDD3V3_A3}
N 7740 -2760 8100 -2760 {lab=VDD3V3_A3}
N 7660 -2600 8100 -2600 {lab=#net1}
N 7700 -2580 8140 -2580 {lab=VSS_1_A3}
N 8140 -2780 8140 -2760 {lab=VDD3V3_A3}
N 8140 -2600 8140 -2580 {lab=VSS_1_A3}
N 7780 -2520 8140 -2520 {lab=VDD3V3_A3}
N 7740 -2500 8100 -2500 {lab=VDD3V3_A3}
N 7660 -2340 8100 -2340 {lab=#net1}
N 7700 -2320 8140 -2320 {lab=VSS_1_A3}
N 8140 -2520 8140 -2500 {lab=VDD3V3_A3}
N 8140 -2340 8140 -2320 {lab=VSS_1_A3}
N 7780 -2260 8140 -2260 {lab=VDD3V3_A3}
N 7740 -2240 8100 -2240 {lab=VDD3V3_A3}
N 7660 -2080 8100 -2080 {lab=#net1}
N 7700 -2060 8140 -2060 {lab=VSS_1_A3}
N 8140 -2260 8140 -2240 {lab=VDD3V3_A3}
N 8140 -2080 8140 -2060 {lab=VSS_1_A3}
N 8140 -1340 8140 -1320 {lab=VDD3V3_A5}
N 7780 -1340 8140 -1340 {lab=VDD3V3_A5}
N 7660 -1160 8100 -1160 {lab=#net1}
N 8140 -1160 8140 -1140 {lab=VSS_A5}
N 7700 -1140 8140 -1140 {lab=VSS_A5}
N 7740 -1320 7830 -1320 {lab=VDD3V3_A5}
N 7890 -1320 7950 -1320 {lab=VDD3V3_A5}
N 7950 -1340 7950 -1320 {lab=VDD3V3_A5}
N 7700 -1630 7700 -920 {lab=VSS_A5}
N 5780 -840 7700 -840 {lab=VSS_A5}
N 7740 -1630 7740 -880 {lab=VDD3V3_A5}
N 5780 -800 7740 -800 {lab=VDD3V3_A5}
N 7780 -1630 7780 -840 {lab=VDD3V3_A5}
N 6340 -760 7780 -760 {lab=VDD3V3_A5}
N 720 -880 2050 -880 {lab=#net1
bus=true}
N 7780 -7200 8140 -7200 {lab=VDD_A4}
N 7740 -7180 8100 -7180 {lab=VDD_A4}
N 7660 -7020 8100 -7020 {lab=#net1}
N 7700 -7000 8140 -7000 {lab=VSS_A4}
N 8140 -7200 8140 -7180 {lab=VDD_A4}
N 8140 -7020 8140 -7000 {lab=VSS_A4}
N 7780 -6940 8140 -6940 {lab=VDD_A4}
N 7740 -6920 8100 -6920 {lab=VDD_A4}
N 7660 -6760 8100 -6760 {lab=#net1}
N 7700 -6740 8140 -6740 {lab=VSS_A4}
N 8140 -6940 8140 -6920 {lab=VDD_A4}
N 8140 -6760 8140 -6740 {lab=VSS_A4}
N 7660 -7300 7660 -880 {lab=#net1
bus=true}
N 8140 -4440 8140 -4420 {lab=VDD3V3_A3}
N 7780 -4440 8140 -4440 {lab=VDD3V3_A3}
N 7660 -4260 8100 -4260 {lab=#net1}
N 8140 -4260 8140 -4240 {lab=VSS_1_A3}
N 7700 -4240 8140 -4240 {lab=VSS_1_A3}
N 7740 -4420 7830 -4420 {lab=VDD3V3_A3}
N 7890 -4420 7950 -4420 {lab=VDD3V3_A3}
N 7950 -4440 7950 -4420 {lab=VDD3V3_A3}
N 8140 -4180 8140 -4160 {lab=VDD3V3_A3}
N 7780 -4180 8140 -4180 {lab=VDD3V3_A3}
N 7740 -4160 8100 -4160 {lab=VDD3V3_A3}
N 8140 -4000 8140 -3980 {lab=VSS_1_A3}
N 7700 -3980 8140 -3980 {lab=VSS_1_A3}
N 7980 -4000 8140 -4000 {lab=VSS_1_A3}
N 7660 -4000 7920 -4000 {lab=#net1}
N 7700 -4460 7700 -1760 {lab=VSS_1_A3
bus=true}
N 7740 -4460 7740 -1760 {lab=VDD3V3_A3}
N 7780 -4460 7780 -1760 {lab=VDD3V3_A3}
N 8140 -2000 8140 -1980 {lab=VDD3V3_A3}
N 7780 -2000 8140 -2000 {lab=VDD3V3_A3}
N 7740 -1980 8100 -1980 {lab=VDD3V3_A3}
N 8140 -1820 8140 -1800 {lab=VSS_2_A3}
N 7980 -1820 8140 -1820 {lab=VSS_2_A3}
N 7660 -1820 7920 -1820 {lab=#net1}
N 7780 -5380 8140 -5380 {lab=VDD_A4}
N 7740 -5360 8100 -5360 {lab=VDD_A4}
N 7660 -5100 8100 -5100 {lab=#net1}
N 7700 -5080 8140 -5080 {lab=VSS_A4}
N 8140 -5380 8140 -5360 {lab=VDD_A4}
N 8140 -5100 8140 -5080 {lab=VSS_A4}
N 7780 -1600 8140 -1600 {lab=VDD3V3_A5}
N 7740 -1580 8100 -1580 {lab=VDD3V3_A5}
N 7660 -1420 8100 -1420 {lab=#net1}
N 7700 -1400 8140 -1400 {lab=VSS_A5}
N 8140 -1600 8140 -1580 {lab=VDD3V3_A5}
N 8140 -1420 8140 -1400 {lab=VSS_A5}
N 7120 -760 7120 -400 {lab=VDD3V3_A5}
N 7140 -800 7140 -440 {lab=VDD3V3_A5}
N 7300 -880 7300 -440 {lab=#net1}
N 7320 -840 7320 -400 {lab=VSS_A5}
N 7120 -400 7140 -400 {lab=VDD3V3_A5}
N 7300 -400 7320 -400 {lab=VSS_A5}
N 6860 -760 6860 -400 {lab=VDD3V3_A5}
N 6880 -800 6880 -440 {lab=VDD3V3_A5}
N 7040 -880 7040 -440 {lab=#net1}
N 7060 -840 7060 -400 {lab=VSS_A5}
N 6860 -400 6880 -400 {lab=VDD3V3_A5}
N 7040 -400 7060 -400 {lab=VSS_A5}
N 6600 -760 6600 -400 {lab=VDD3V3_A5}
N 6620 -800 6620 -440 {lab=VDD3V3_A5}
N 6780 -880 6780 -440 {lab=#net1}
N 6800 -840 6800 -400 {lab=VSS_A5}
N 6600 -400 6620 -400 {lab=VDD3V3_A5}
N 6780 -400 6800 -400 {lab=VSS_A5}
N 6080 -760 6080 -400 {lab=VDD3V3_A5}
N 6100 -800 6100 -440 {lab=VDD3V3_A5}
N 6260 -880 6260 -440 {lab=#net1}
N 6280 -840 6280 -400 {lab=VSS_A5}
N 6080 -400 6100 -400 {lab=VDD3V3_A5}
N 6260 -400 6280 -400 {lab=VSS_A5}
N 6340 -400 6360 -400 {lab=VDD3V3_A5}
N 6340 -760 6340 -400 {lab=VDD3V3_A5}
N 6360 -800 6360 -440 {lab=VDD3V3_A5}
N 6520 -400 6540 -400 {lab=VSS_A5}
N 6540 -840 6540 -400 {lab=VSS_A5}
N 6520 -560 6520 -400 {lab=VSS_A5}
N 6520 -880 6520 -620 {lab=#net1}
N 2050 -880 7660 -880 {lab=#net1
bus=true}
N 7700 -920 7700 -840 {lab=VSS_A5}
N 7660 -960 7660 -880 {lab=#net1
bus=true}
N 7700 -920 7700 -840 {lab=VSS_A5}
N 7740 -880 7740 -800 {lab=VDD3V3_A5}
N 7660 -960 7660 -880 {lab=#net1
bus=true}
N 7700 -920 7700 -840 {lab=VSS_A5}
N 7740 -880 7740 -800 {lab=VDD3V3_A5}
N 7780 -840 7780 -760 {lab=VDD3V3_A5}
N 7660 -960 7660 -880 {lab=#net1
bus=true}
N 5820 -760 5820 -400 {lab=VDD3V3_A5}
N 5840 -800 5840 -440 {lab=VDD3V3_A5}
N 6000 -880 6000 -440 {lab=#net1}
N 6020 -840 6020 -400 {lab=VSS_A5}
N 5820 -400 5840 -400 {lab=VDD3V3_A5}
N 6000 -400 6020 -400 {lab=VSS_A5}
N 5780 -760 6340 -760 {lab=VDD3V3_A5}
N 1840 -840 5690 -840 {lab=VSS_AXX
bus=true}
N 1840 -800 5690 -800 {lab=VDD3V3_AXX
bus=true}
N 1840 -760 5690 -760 {lab=VDD3V3_AXX
bus=true}
N 2240 -400 2260 -400 {lab=VDD3V3_AXX}
N 2240 -760 2240 -400 {lab=VDD3V3_AXX}
N 2420 -880 2420 -440 {lab=#net1}
N 2420 -400 2440 -400 {lab=VSS_AXX}
N 2440 -840 2440 -400 {lab=VSS_AXX}
N 2260 -800 2260 -710 {lab=VDD3V3_AXX}
N 2260 -650 2260 -590 {lab=VDD3V3_AXX}
N 2240 -590 2260 -590 {lab=VDD3V3_AXX}
N 2760 -760 2760 -400 {lab=VDD3V3_AXX}
N 2780 -800 2780 -440 {lab=VDD3V3_AXX}
N 2940 -880 2940 -440 {lab=#net1}
N 2960 -840 2960 -400 {lab=VSS_AXX}
N 2760 -400 2780 -400 {lab=VDD3V3_AXX}
N 2940 -400 2960 -400 {lab=VSS_AXX}
N 2500 -760 2500 -400 {lab=VDD3V3_AXX}
N 2520 -800 2520 -440 {lab=VDD3V3_AXX}
N 2680 -880 2680 -440 {lab=#net1}
N 2700 -840 2700 -400 {lab=VSS_AXX}
N 2500 -400 2520 -400 {lab=VDD3V3_AXX}
N 2680 -400 2700 -400 {lab=VSS_AXX}
N 3020 -400 3040 -400 {lab=VDD3V3_AXX}
N 3020 -760 3020 -400 {lab=VDD3V3_AXX}
N 3040 -800 3040 -440 {lab=VDD3V3_AXX}
N 3200 -400 3220 -400 {lab=VSS_AXX}
N 3220 -840 3220 -400 {lab=VSS_AXX}
N 3200 -560 3200 -400 {lab=VSS_AXX}
N 3200 -880 3200 -620 {lab=#net1}
N 3540 -760 3540 -400 {lab=VDD3V3_AXX}
N 3560 -800 3560 -440 {lab=VDD3V3_AXX}
N 3720 -880 3720 -440 {lab=#net1}
N 3740 -840 3740 -400 {lab=VSS_AXX}
N 3540 -400 3560 -400 {lab=VDD3V3_AXX}
N 3720 -400 3740 -400 {lab=VSS_AXX}
N 3280 -760 3280 -400 {lab=VDD3V3_AXX}
N 3300 -800 3300 -440 {lab=VDD3V3_AXX}
N 3460 -880 3460 -440 {lab=#net1}
N 3480 -840 3480 -400 {lab=VSS_AXX}
N 3280 -400 3300 -400 {lab=VDD3V3_AXX}
N 3460 -400 3480 -400 {lab=VSS_AXX}
N 4060 -760 4060 -400 {lab=VDD3V3_AXX}
N 4080 -800 4080 -440 {lab=VDD3V3_AXX}
N 4240 -880 4240 -440 {lab=#net1}
N 4260 -840 4260 -400 {lab=VSS_AXX}
N 4060 -400 4080 -400 {lab=VDD3V3_AXX}
N 4240 -400 4260 -400 {lab=VSS_AXX}
N 3800 -760 3800 -400 {lab=VDD3V3_AXX}
N 3820 -800 3820 -440 {lab=VDD3V3_AXX}
N 3980 -880 3980 -440 {lab=#net1}
N 4000 -840 4000 -400 {lab=VSS_AXX}
N 3800 -400 3820 -400 {lab=VDD3V3_AXX}
N 3980 -400 4000 -400 {lab=VSS_AXX}
N 4580 -760 4580 -400 {lab=VDD3V3_AXX}
N 4600 -800 4600 -440 {lab=VDD3V3_AXX}
N 4760 -880 4760 -440 {lab=#net1}
N 4780 -840 4780 -400 {lab=VSS_AXX}
N 4580 -400 4600 -400 {lab=VDD3V3_AXX}
N 4760 -400 4780 -400 {lab=VSS_AXX}
N 4320 -760 4320 -400 {lab=VDD3V3_AXX}
N 4340 -800 4340 -440 {lab=VDD3V3_AXX}
N 4500 -880 4500 -440 {lab=#net1}
N 4520 -840 4520 -400 {lab=VSS_AXX}
N 4320 -400 4340 -400 {lab=VDD3V3_AXX}
N 4500 -400 4520 -400 {lab=VSS_AXX}
N 5100 -760 5100 -400 {lab=VDD3V3_AXX}
N 5120 -800 5120 -440 {lab=VDD3V3_AXX}
N 5280 -880 5280 -440 {lab=#net1}
N 5300 -840 5300 -400 {lab=VSS_AXX}
N 5100 -400 5120 -400 {lab=VDD3V3_AXX}
N 5280 -400 5300 -400 {lab=VSS_AXX}
N 4840 -760 4840 -400 {lab=VDD3V3_AXX}
N 4860 -800 4860 -440 {lab=VDD3V3_AXX}
N 5020 -880 5020 -440 {lab=#net1}
N 5040 -840 5040 -400 {lab=VSS_AXX}
N 4840 -400 4860 -400 {lab=VDD3V3_AXX}
N 5020 -400 5040 -400 {lab=VSS_AXX}
N 1920 -760 1920 -400 {lab=VDD3V3_AXX}
N 1940 -800 1940 -440 {lab=VDD3V3_AXX}
N 2100 -880 2100 -440 {lab=#net1}
N 2120 -840 2120 -400 {lab=VSS_AXX}
N 1920 -400 1940 -400 {lab=VDD3V3_AXX}
N 2100 -400 2120 -400 {lab=VSS_AXX}
N 5420 -760 5420 -400 {lab=VDD3V3_AXX}
N 5440 -800 5440 -440 {lab=VDD3V3_AXX}
N 5600 -880 5600 -440 {lab=#net1}
N 5620 -840 5620 -400 {lab=VSS_AXX}
N 5420 -400 5440 -400 {lab=VDD3V3_AXX}
N 5600 -400 5620 -400 {lab=VSS_AXX}
N 8140 -1800 8150 -1800 {lab=VSS_2_A3}
N 8210 -1800 8220 -1800 {lab=VSS_2_A3}
N 8140 -3980 8150 -3980 {lab=VSS_1_A3}
N 8210 -3980 8220 -3980 {lab=VSS_1_A3}
N 7890 -1800 8140 -1800 {lab=VSS_2_A3}
N 7700 -1800 7830 -1800 {lab=VSS_1_A3}
N 4810 -7780 4810 -7420 {lab=VDD_A1}
N 4790 -7740 4790 -7380 {lab=VDD_A1}
N 4630 -7740 4630 -7300 {lab=#net1}
N 4610 -7780 4610 -7340 {lab=VSS_A1}
N 4790 -7780 4810 -7780 {lab=VDD_A1}
N 4610 -7780 4630 -7780 {lab=VSS_A1}
N 4580 -7340 7660 -7340 {lab=VSS_A1
bus=true}
N 4580 -7380 7660 -7380 {lab=VDD_A1
bus=true}
N 4580 -7420 7660 -7420 {lab=VDD_A1
bus=true}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 2420 -7860 1 0 {name=IO_TEST_IBIAS
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 7430 -7860 1 0 {name=IO_VDD_A1
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 7180 -7860 1 0 {name=IOVSS
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2660 -7860 1 0 {name=IO_TEST_IBIAS_OVRD
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 3380 -7860 1 0 {name=IO_VCO_OUT
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1060 -7860 1 0 {name=IO_TEST_SEL_2
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1400 -7860 1 0 {name=IO_TEST_SEL_1
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1740 -7860 1 0 {name=IO_TEST_SEL_0
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 3000 -7860 1 0 {name=IO_VTEST
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {ipin.sym} 1860 -7860 1 0 {name=p77 lab=TEST_SEL_0_PAD}
C {ipin.sym} 1520 -7860 1 0 {name=p78 lab=TEST_SEL_1_PAD}
C {ipin.sym} 1180 -7860 1 0 {name=p79 lab=TEST_SEL_2_PAD}
C {iopin.sym} 5910 -7860 3 0 {name=p80 lab=LDO_VREF_PAD}
C {iopin.sym} 5290 -7860 3 0 {name=p81 lab=LDO_IBIAS_PAD}
C {iopin.sym} 2500 -7860 3 0 {name=p83 lab=TEST_IBIAS_PAD}
C {ipin.sym} 6210 -7860 1 0 {name=p84 lab=LDO_VREF_OVRD_PAD}
C {ipin.sym} 5570 -7860 1 0 {name=p85 lab=LDO_IBIAS_OVRD_PAD}
C {ipin.sym} 2780 -7860 1 0 {name=p87 lab=TEST_IBIAS_OVRD_PAD}
C {ipin.sym} 2200 -7860 1 0 {name=p89 lab=TEST_EN_PAD}
C {ipin.sym} 6890 -7860 1 0 {name=p91 lab=BIAS_EN_PAD}
C {ipin.sym} 6550 -7860 1 0 {name=p94 lab=LDO_EN_PAD}
C {iopin.sym} 3180 -7840 3 0 {name=p96 lab=VTEST}
C {iopin.sym} 3500 -7860 1 1 {name=p98 lab=VCO_OUT_PAD}
C {iopin.sym} 900 -7860 3 0 {name=p99 lab=TEST_OUT_PAD}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -6260 0 0 {name=IO_VCM_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 4870 -7860 1 0 {name=IO_VCO_IBIAS_OVRD
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {iopin.sym} 160 -6340 2 0 {name=p103 lab=VCM_A2_PAD}
C {ipin.sym} 4990 -7860 1 0 {name=p104 lab=VCO_IBIAS_OVRD_PAD}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 3720 -7860 1 0 {name=IO_VCO_EN
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 3840 -7860 1 0 {name=p120 lab=VCO_EN_PAD}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 4060 -7860 1 0 {name=IO_VCO_IN
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4140 -7860 3 0 {name=p34 lab=VCO_IN_PAD}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 5210 -7860 1 0 {name=IO_LDO_IBIAS
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 5450 -7860 1 0 {name=IO_LDO_IBIAS_OVRD
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 5830 -7860 1 0 {name=IO_LCO_VREF
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 6090 -7860 1 0 {name=IO_LDO_VREF_OVRD
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 6430 -7860 1 0 {name=IO_LDO_EN
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 2080 -7860 1 0 {name=IO_TEST_EN
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 820 -7860 1 0 {name=IO_LCO_VREF2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 2500 -7660 1 0 {name=p4 lab=test_ibias_int}
C {iopin.sym} 4140 -7660 1 0 {name=p31 lab=vco_in_int}
C {opin.sym} 5630 -7600 1 0 {name=p114 lab=LDO_IBIAS_OVRD_Y}
C {opin.sym} 6610 -7600 1 0 {name=p168 lab=LDO_EN_Y}
C {iopin.sym} 5910 -7660 3 1 {name=p169 lab=LDO_VREF_ASIG5V}
C {iopin.sym} 5290 -7660 3 1 {name=p170 lab=LDO_IBIAS_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 6770 -7860 1 0 {name=IO_LDO_EN1
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 6810 -7600 3 0 {name=p5 lab=BIAS_EN_OE}
C {ipin.sym} 6830 -7600 3 0 {name=p3 lab=BIAS_EN_SL}
C {ipin.sym} 6850 -7600 3 0 {name=p2 lab=BIAS_EN_A}
C {ipin.sym} 6870 -7600 3 0 {name=p6 lab=BIAS_EN_PDRV1}
C {ipin.sym} 6890 -7600 3 0 {name=p7 lab=BIAS_EN_PDRV0}
C {ipin.sym} 6910 -7600 3 0 {name=p8 lab=BIAS_EN_PD}
C {ipin.sym} 6930 -7600 3 0 {name=p9 lab=BIAS_EN_PU}
C {opin.sym} 6950 -7600 1 0 {name=p179 lab=BIAS_EN_Y}
C {ipin.sym} 6970 -7600 3 0 {name=p10 lab=BIAS_EN_CS}
C {ipin.sym} 6990 -7600 3 0 {name=p11 lab=BIAS_EN_IE}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 4320 -7860 1 0 {name=IO_LDO_OUT
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 7160 -7840 3 0 {name=p51 lab=VSS_A1}
C {title.sym} 160 -40 0 0 {name=l1 author="Luighi Viton (Analog/AI Track)"}
C {iopin.sym} 360 -6340 2 1 {name=p23 lab=VCM_A2_ASIG5V}
C {short.sym} 7160 -7810 0 0 {name=x2 value=0.1}
C {iopin.sym} 7610 -7840 3 0 {name=p1 lab=VDD_A1}
C {short.sym} 7610 -7810 0 0 {name=x3 value=0.1}
C {ipin.sym} 6470 -7600 3 0 {name=p12 lab=LDO_EN_OE}
C {ipin.sym} 6490 -7600 3 0 {name=p13 lab=LDO_EN_SL}
C {ipin.sym} 6510 -7600 3 0 {name=p14 lab=LDO_EN_A}
C {ipin.sym} 6530 -7600 3 0 {name=p15 lab=LDO_EN_PDRV1}
C {ipin.sym} 6550 -7600 3 0 {name=p18 lab=LDO_EN_PDRV0}
C {ipin.sym} 6570 -7600 3 0 {name=p19 lab=LDO_EN_PD}
C {ipin.sym} 6590 -7600 3 0 {name=p21 lab=LDO_EN_PU}
C {ipin.sym} 6630 -7600 3 0 {name=p22 lab=LDO_EN_CS}
C {ipin.sym} 6650 -7600 3 0 {name=p26 lab=LDO_EN_IE}
C {opin.sym} 6270 -7600 1 0 {name=p27 lab=LDO_VREF_OVRD_Y}
C {ipin.sym} 6130 -7600 3 0 {name=p28 lab=LDO_VREF_OVRD_OE}
C {ipin.sym} 6150 -7600 3 0 {name=p29 lab=LDO_VREF_OVRD_SL}
C {ipin.sym} 6170 -7600 3 0 {name=p30 lab=LDO_VREF_OVRD_A}
C {ipin.sym} 6190 -7600 3 0 {name=p32 lab=LDO_VREF_OVRD_PDRV1}
C {ipin.sym} 6210 -7600 3 0 {name=p33 lab=LDO_VREF_OVRD_PDRV0}
C {ipin.sym} 6230 -7600 3 0 {name=p35 lab=LDO_VREF_OVRD_PD}
C {ipin.sym} 6250 -7600 3 0 {name=p36 lab=LDO_VREF_OVRD_PU}
C {ipin.sym} 6290 -7600 3 0 {name=p37 lab=LDO_VREF_OVRD_CS}
C {ipin.sym} 6310 -7600 3 0 {name=p38 lab=LDO_VREF_OVRD_IE}
C {ipin.sym} 5490 -7600 3 0 {name=p39 lab=LDO_IBIAS_OVRD_OE}
C {ipin.sym} 5510 -7600 3 0 {name=p40 lab=LDO_IBIAS_OVRD_SL}
C {ipin.sym} 5530 -7600 3 0 {name=p41 lab=LDO_IBIAS_OVRD_A}
C {ipin.sym} 5550 -7600 3 0 {name=p42 lab=LDO_IBIAS_OVRD_PDRV1}
C {ipin.sym} 5570 -7600 3 0 {name=p43 lab=LDO_IBIAS_OVRD_PDRV0}
C {ipin.sym} 5590 -7600 3 0 {name=p44 lab=LDO_IBIAS_OVRD_PD}
C {ipin.sym} 5610 -7600 3 0 {name=p45 lab=LDO_IBIAS_OVRD_PU}
C {ipin.sym} 5650 -7600 3 0 {name=p46 lab=LDO_IBIAS_OVRD_CS}
C {ipin.sym} 5670 -7600 3 0 {name=p47 lab=LDO_IBIAS_OVRD_IE}
C {opin.sym} 5050 -7600 1 0 {name=p48 lab=VCO_IBIAS_OVRD_Y}
C {ipin.sym} 4910 -7600 3 0 {name=p49 lab=VCO_IBIAS_OVRD_OE}
C {ipin.sym} 4930 -7600 3 0 {name=p52 lab=VCO_IBIAS_OVRD_SL}
C {ipin.sym} 4950 -7600 3 0 {name=p53 lab=VCO_IBIAS_OVRD_A}
C {ipin.sym} 4970 -7600 3 0 {name=p54 lab=VCO_IBIAS_OVRD_PDRV1}
C {ipin.sym} 4990 -7600 3 0 {name=p55 lab=VCO_IBIAS_OVRD_PDRV0}
C {ipin.sym} 5010 -7600 3 0 {name=p56 lab=VCO_IBIAS_OVRD_PD}
C {ipin.sym} 5030 -7600 3 0 {name=p57 lab=VCO_IBIAS_OVRD_PU}
C {ipin.sym} 5070 -7600 3 0 {name=p58 lab=VCO_IBIAS_OVRD_CS}
C {ipin.sym} 5090 -7600 3 0 {name=p59 lab=VCO_IBIAS_OVRD_IE}
C {iopin.sym} 4500 -7840 3 0 {name=p60 lab=LDO_OUT}
C {short.sym} 4500 -7810 0 0 {name=x4 value=0.1}
C {opin.sym} 3900 -7600 1 0 {name=p61 lab=VCO_EN_Y}
C {ipin.sym} 3760 -7600 3 0 {name=p62 lab=VCO_EN_OE}
C {ipin.sym} 3780 -7600 3 0 {name=p63 lab=VCO_EN_SL}
C {ipin.sym} 3800 -7600 3 0 {name=p64 lab=VCO_EN_A}
C {ipin.sym} 3820 -7600 3 0 {name=p66 lab=VCO_EN_PDRV1}
C {ipin.sym} 3840 -7600 3 0 {name=p67 lab=VCO_EN_PDRV0}
C {ipin.sym} 3860 -7600 3 0 {name=p68 lab=VCO_EN_PD}
C {ipin.sym} 3880 -7600 3 0 {name=p69 lab=VCO_EN_PU}
C {ipin.sym} 3920 -7600 3 0 {name=p70 lab=VCO_EN_CS}
C {ipin.sym} 3940 -7600 3 0 {name=p71 lab=VCO_EN_IE}
C {opin.sym} 3560 -7600 1 0 {name=p72 lab=VCO_OUT_Y}
C {ipin.sym} 3420 -7600 3 0 {name=p74 lab=VCO_OUT_OE}
C {ipin.sym} 3440 -7600 3 0 {name=p75 lab=VCO_OUT_SL}
C {ipin.sym} 3460 -7600 3 0 {name=p76 lab=VCO_OUT_A}
C {ipin.sym} 3480 -7600 3 0 {name=p82 lab=VCO_OUT_PDRV1}
C {ipin.sym} 3500 -7600 3 0 {name=p86 lab=VCO_OUT_PDRV0}
C {ipin.sym} 3520 -7600 3 0 {name=p88 lab=VCO_OUT_PD}
C {ipin.sym} 3540 -7600 3 0 {name=p90 lab=VCO_OUT_PU}
C {ipin.sym} 3580 -7600 3 0 {name=p92 lab=VCO_OUT_CS}
C {ipin.sym} 3600 -7600 3 0 {name=p93 lab=VCO_OUT_IE}
C {short.sym} 3180 -7810 0 0 {name=x5 value=0.1}
C {opin.sym} 2840 -7600 1 0 {name=p20 lab=TEST_IBIAS_OVRD_Y}
C {ipin.sym} 2700 -7600 3 0 {name=p50 lab=TEST_IBIAS_OVRD_OE}
C {ipin.sym} 2720 -7600 3 0 {name=p95 lab=TEST_IBIAS_OVRD_SL}
C {ipin.sym} 2740 -7600 3 0 {name=p97 lab=TEST_IBIAS_OVRD_A}
C {ipin.sym} 2760 -7600 3 0 {name=p100 lab=TEST_IBIAS_OVRD_PDRV1}
C {ipin.sym} 2780 -7600 3 0 {name=p101 lab=TEST_IBIAS_OVRD_PDRV0}
C {ipin.sym} 2800 -7600 3 0 {name=p102 lab=TEST_IBIAS_OVRD_PD}
C {ipin.sym} 2820 -7600 3 0 {name=p105 lab=TEST_IBIAS_OVRD_PU}
C {ipin.sym} 2860 -7600 3 0 {name=p106 lab=TEST_IBIAS_OVRD_CS}
C {ipin.sym} 2880 -7600 3 0 {name=p107 lab=TEST_IBIAS_OVRD_IE}
C {opin.sym} 2260 -7600 1 0 {name=p65 lab=TEST_EN_Y}
C {ipin.sym} 2120 -7600 3 0 {name=p108 lab=TEST_EN_OE}
C {ipin.sym} 2140 -7600 3 0 {name=p109 lab=TEST_EN_SL}
C {ipin.sym} 2160 -7600 3 0 {name=p110 lab=TEST_EN_A}
C {ipin.sym} 2180 -7600 3 0 {name=p111 lab=TEST_EN_PDRV1}
C {ipin.sym} 2200 -7600 3 0 {name=p112 lab=TEST_EN_PDRV0}
C {ipin.sym} 2220 -7600 3 0 {name=p113 lab=TEST_EN_PD}
C {ipin.sym} 2240 -7600 3 0 {name=p115 lab=TEST_EN_PU}
C {ipin.sym} 2280 -7600 3 0 {name=p116 lab=TEST_EN_CS}
C {ipin.sym} 2300 -7600 3 0 {name=p117 lab=TEST_EN_IE}
C {opin.sym} 1920 -7600 1 0 {name=p118 lab=TEST_SEL_0_Y}
C {ipin.sym} 1780 -7600 3 0 {name=p119 lab=TEST_SEL_0_OE}
C {ipin.sym} 1800 -7600 3 0 {name=p121 lab=TEST_SEL_0_SL}
C {ipin.sym} 1820 -7600 3 0 {name=p122 lab=TEST_SEL_0_A}
C {ipin.sym} 1840 -7600 3 0 {name=p123 lab=TEST_SEL_0_PDRV1}
C {ipin.sym} 1860 -7600 3 0 {name=p124 lab=TEST_SEL_0_PDRV0}
C {ipin.sym} 1880 -7600 3 0 {name=p125 lab=TEST_SEL_0_PD}
C {ipin.sym} 1900 -7600 3 0 {name=p126 lab=TEST_SEL_0_PU}
C {ipin.sym} 1940 -7600 3 0 {name=p127 lab=TEST_SEL_0_CS}
C {ipin.sym} 1960 -7600 3 0 {name=p128 lab=TEST_SEL_0_IE}
C {opin.sym} 1580 -7600 1 0 {name=p73 lab=TEST_SEL_1_Y}
C {ipin.sym} 1440 -7600 3 0 {name=p129 lab=TEST_SEL_1_OE}
C {ipin.sym} 1460 -7600 3 0 {name=p130 lab=TEST_SEL_1_SL}
C {ipin.sym} 1480 -7600 3 0 {name=p131 lab=TEST_SEL_1_A}
C {ipin.sym} 1500 -7600 3 0 {name=p132 lab=TEST_SEL_1_PDRV1}
C {ipin.sym} 1520 -7600 3 0 {name=p133 lab=TEST_SEL_1_PDRV0}
C {ipin.sym} 1540 -7600 3 0 {name=p134 lab=TEST_SEL_1_PD}
C {ipin.sym} 1560 -7600 3 0 {name=p135 lab=TEST_SEL_1_PU}
C {ipin.sym} 1600 -7600 3 0 {name=p136 lab=TEST_SEL_1_CS}
C {ipin.sym} 1620 -7600 3 0 {name=p137 lab=TEST_SEL_1_IE}
C {opin.sym} 1240 -7600 1 0 {name=p138 lab=TEST_SEL_2_Y}
C {ipin.sym} 1100 -7600 3 0 {name=p139 lab=TEST_SEL_2_OE}
C {ipin.sym} 1120 -7600 3 0 {name=p140 lab=TEST_SEL_2_SL}
C {ipin.sym} 1140 -7600 3 0 {name=p141 lab=TEST_SEL_2_A}
C {ipin.sym} 1160 -7600 3 0 {name=p142 lab=TEST_SEL_2_PDRV1}
C {ipin.sym} 1180 -7600 3 0 {name=p143 lab=TEST_SEL_2_PDRV0}
C {ipin.sym} 1200 -7600 3 0 {name=p144 lab=TEST_SEL_2_PD}
C {ipin.sym} 1220 -7600 3 0 {name=p145 lab=TEST_SEL_2_PU}
C {ipin.sym} 1260 -7600 3 0 {name=p146 lab=TEST_SEL_2_CS}
C {ipin.sym} 1280 -7600 3 0 {name=p147 lab=TEST_SEL_2_IE}
C {iopin.sym} 900 -7660 1 0 {name=p148 lab=TEST_OUT_ASIG5V}
C {short.sym} 3160 -7500 0 0 {name=x6 value=0.1}
C {short.sym} 4480 -7500 0 0 {name=x7 value=0.1}
C {short.sym} 7590 -7500 0 0 {name=x8 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 160 -6780 0 0 {name=IO_AVDD_A2
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 160 -6530 0 0 {name=IO_AVSS_A2
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 180 -6510 2 0 {name=p16 lab=AVSS_A2}
C {short.sym} 210 -6510 3 0 {name=x10 value=0.1}
C {iopin.sym} 180 -6960 2 0 {name=p17 lab=AVDD_A2}
C {short.sym} 210 -6960 3 0 {name=x11 value=0.1}
C {short.sym} 520 -6940 3 0 {name=x12 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -6000 0 0 {name=IO_VBIAS_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -6080 2 0 {name=p24 lab=VBIAS_A2_PAD}
C {iopin.sym} 360 -6080 2 1 {name=p25 lab=VBIAS_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -5740 0 0 {name=IO_IN1P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -5820 2 0 {name=p149 lab=IN1P_A2_PAD}
C {iopin.sym} 360 -5820 2 1 {name=p150 lab=IN1P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -5480 0 0 {name=IO_IN1N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -5560 2 0 {name=p151 lab=IN1N_A2_PAD}
C {iopin.sym} 360 -5560 2 1 {name=p152 lab=IN1N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -5220 0 0 {name=IO_IN2P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -5300 2 0 {name=p153 lab=IN2P_A2_PAD}
C {iopin.sym} 360 -5300 2 1 {name=p154 lab=IN2P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -4960 0 0 {name=IO_IN2N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -5040 2 0 {name=p155 lab=IN2N_A2_PAD}
C {iopin.sym} 360 -5040 2 1 {name=p156 lab=IN2N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -4700 0 0 {name=IO_IN3P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -4780 2 0 {name=p157 lab=IN3P_A2_PAD}
C {iopin.sym} 360 -4780 2 1 {name=p158 lab=IN3P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -4440 0 0 {name=IO_IN3N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -4520 2 0 {name=p159 lab=IN3N_A2_PAD}
C {iopin.sym} 360 -4520 2 1 {name=p160 lab=IN3N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -4180 0 0 {name=IO_IN4P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -4260 2 0 {name=p161 lab=IN4P_A2_PAD}
C {iopin.sym} 360 -4260 2 1 {name=p162 lab=IN4P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -3920 0 0 {name=IO_IN4N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -4000 2 0 {name=p163 lab=IN4N_A2_PAD}
C {iopin.sym} 360 -4000 2 1 {name=p164 lab=IN4N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -3660 0 0 {name=IO_OUT1P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -3740 2 0 {name=p165 lab=OUT1P_A2_PAD}
C {iopin.sym} 360 -3740 2 1 {name=p166 lab=OUT1P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -3400 0 0 {name=IO_OUT1N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -3480 2 0 {name=p167 lab=OUT1N_A2_PAD}
C {iopin.sym} 360 -3480 2 1 {name=p171 lab=OUT1N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -3140 0 0 {name=IO_OUT2P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -3220 2 0 {name=p172 lab=OUT2P_A2_PAD}
C {iopin.sym} 360 -3220 2 1 {name=p173 lab=OUT2P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -2880 0 0 {name=IO_OUT2N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -2960 2 0 {name=p174 lab=OUT2N_A2_PAD}
C {iopin.sym} 360 -2960 2 1 {name=p175 lab=OUT2N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -2620 0 0 {name=IO_OUT3P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -2360 0 0 {name=IO_OUT3N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -2100 0 0 {name=IO_OUT4P_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -2180 2 0 {name=p181 lab=OUT4P_A2_PAD}
C {iopin.sym} 360 -2180 2 1 {name=p182 lab=OUT4P_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 160 -1840 0 0 {name=IO_OUT4N_A2
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 160 -1920 2 0 {name=p183 lab=OUT4N_A2_PAD}
C {iopin.sym} 360 -1920 2 1 {name=p184 lab=OUT4N_A2_ASIG5V}
C {iopin.sym} 160 -2700 2 0 {name=p176 lab=OUT3P_A2_PAD}
C {iopin.sym} 360 -2700 2 1 {name=p177 lab=OUT3P_A2_ASIG5V}
C {iopin.sym} 160 -2440 2 0 {name=p178 lab=OUT3N_A2_PAD}
C {iopin.sym} 360 -2440 2 1 {name=p180 lab=OUT3N_A2_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 160 -1420 0 0 {name=IO_VDD_A2
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 180 -1600 2 0 {name=p185 lab=VDD_A2}
C {short.sym} 210 -1600 3 0 {name=x13 value=0.1}
C {short.sym} 520 -1580 3 0 {name=x14 value=0.1}
C {ipin.sym} 160 -1180 0 0 {name=p186 lab=CLK_IN_A2_PAD}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 160 -1060 0 0 {name=IO_CLK_IN_A2
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 420 -1100 2 0 {name=p187 lab=CLK_IN_A2_OE}
C {ipin.sym} 420 -1120 2 0 {name=p188 lab=CLK_IN_A2_SL}
C {ipin.sym} 420 -1140 2 0 {name=p189 lab=CLK_IN_A2_A}
C {ipin.sym} 420 -1160 2 0 {name=p190 lab=CLK_IN_A2_PDRV1}
C {ipin.sym} 420 -1180 2 0 {name=p191 lab=CLK_IN_A2_PDRV0}
C {ipin.sym} 420 -1200 2 0 {name=p192 lab=CLK_IN_A2_PD}
C {ipin.sym} 420 -1220 2 0 {name=p193 lab=CLK_IN_A2_PU}
C {opin.sym} 420 -1240 0 0 {name=p194 lab=CLK_IN_A2_Y}
C {ipin.sym} 420 -1260 2 0 {name=p195 lab=CLK_IN_A2_CS}
C {ipin.sym} 420 -1280 2 0 {name=p196 lab=CLK_IN_A2_IE}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 1280 -320 3 0 {name=IO_VSS_A2
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 1300 -340 1 0 {name=p197 lab=VSS_A2}
C {short.sym} 1300 -370 2 0 {name=x16 value=0.1}
C {ipin.sym} 1520 -320 3 0 {name=p198 lab=RST_N_A2_PAD}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 1640 -320 3 0 {name=IO_RST_N_A2
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 1600 -580 1 0 {name=p199 lab=RST_N_A2_OE}
C {ipin.sym} 1580 -580 1 0 {name=p200 lab=RST_N_A2_SL}
C {ipin.sym} 1560 -580 1 0 {name=p201 lab=RST_N_A2_A}
C {ipin.sym} 1540 -580 1 0 {name=p202 lab=RST_N_A2_PDRV1}
C {ipin.sym} 1520 -580 1 0 {name=p203 lab=RST_N_A2_PDRV0}
C {ipin.sym} 1500 -580 1 0 {name=p204 lab=RST_N_A2_PD}
C {ipin.sym} 1480 -580 1 0 {name=p205 lab=RST_N_A2_PU}
C {opin.sym} 1460 -580 3 0 {name=p206 lab=RST_N_A2_Y}
C {ipin.sym} 1440 -580 1 0 {name=p207 lab=RST_N_A2_CS}
C {ipin.sym} 1420 -580 1 0 {name=p208 lab=RST_N_A2_IE}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -6500 0 1 {name=IO_VOUT90
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -6580 2 1 {name=p209 lab=VOUT90_PAD}
C {iopin.sym} 8020 -6580 2 0 {name=p210 lab=VOUT90_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 8220 -4570 0 1 {name=IO_AVDD_A1
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 8220 -4840 0 1 {name=IO_AVSS_A1
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 8200 -4820 2 1 {name=p211 lab=VSS_A4}
C {short.sym} 8170 -4820 1 1 {name=x18 value=0.1}
C {iopin.sym} 8200 -4750 2 1 {name=p212 lab=VDD_A4}
C {short.sym} 8170 -4750 1 1 {name=x19 value=0.1}
C {short.sym} 7860 -4730 1 1 {name=x20 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -6240 0 1 {name=IO_VOUT0
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -6320 2 1 {name=p213 lab=VOUT0_PAD}
C {iopin.sym} 8020 -6320 2 0 {name=p214 lab=VOUT0_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -5980 0 1 {name=IO_IBIAS
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -6060 2 1 {name=p215 lab=IBIAS_PAD}
C {iopin.sym} 8020 -6060 2 0 {name=p216 lab=IBIAS_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -5720 0 1 {name=IO_VCTRL
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -5800 2 1 {name=p217 lab=VCTRL_PAD}
C {iopin.sym} 8020 -5800 2 0 {name=p218 lab=VCTRL_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -5460 0 1 {name=IO_VREF
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -5540 2 1 {name=p219 lab=VREF_PAD}
C {iopin.sym} 8020 -5540 2 0 {name=p220 lab=VREF_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -3740 0 1 {name=IO_V_IN_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -3820 2 1 {name=p231 lab=V_IN_A3_PAD}
C {iopin.sym} 8020 -3820 2 0 {name=p232 lab=V_IN_A3_ASIGV5}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -3480 0 1 {name=IO_V_AUX_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -3560 2 1 {name=p233 lab=V_AUX_A3_PAD}
C {iopin.sym} 8020 -3560 2 0 {name=p234 lab=V_AUX_A3_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -2860 0 1 {name=IO_V_BIAS_EN_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -2940 2 1 {name=p237 lab=V_BIAS_EN_A3_PAD}
C {iopin.sym} 8020 -2940 2 0 {name=p238 lab=V_BIAS_EN_A3_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -2600 0 1 {name=IO_CCM_OUT_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -2340 0 1 {name=IO_BCM_OUT_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -2080 0 1 {name=IO_VCM_OUT_A3
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -2160 2 1 {name=p239 lab=VCM_OUT_A3_PAD}
C {iopin.sym} 8020 -2160 2 0 {name=p240 lab=VCM_OUT_A3_ASIG5V}
C {iopin.sym} 8220 -2680 2 1 {name=p243 lab=CCM_OUT_A3_PAD}
C {iopin.sym} 8020 -2680 2 0 {name=p244 lab=CCM_OUT_A3_ASIG5V}
C {iopin.sym} 8220 -2420 2 1 {name=p245 lab=BCM_OUT_A3_PAD}
C {iopin.sym} 8020 -2420 2 0 {name=p246 lab=BCM_OUT_A3_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 8220 -1160 0 1 {name=IO_VDD_A3
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 8200 -1340 2 1 {name=p247 lab=VDD3V3_A5}
C {short.sym} 8170 -1340 1 1 {name=x21 value=0.1}
C {short.sym} 7860 -1320 1 1 {name=x22 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -7020 0 1 {name=IO_VOUT270
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -7100 2 1 {name=p271 lab=VOUT270_PAD}
C {iopin.sym} 8020 -7100 2 0 {name=p272 lab=VOUT270_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -6760 0 1 {name=IO_VOUT180
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -6840 2 1 {name=p273 lab=VOUT180_PAD}
C {iopin.sym} 8020 -6840 2 0 {name=p274 lab=VOUT180_ASIG5V}
C {ipin.sym} 8220 -3260 2 0 {name=p275 lab=EN_A3_PAD}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 8220 -3380 2 0 {name=IO_EN_A3
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 7960 -3340 0 0 {name=p276 lab=EN_A3_OE}
C {ipin.sym} 7960 -3320 0 0 {name=p277 lab=EN_A3_SL}
C {ipin.sym} 7960 -3300 0 0 {name=p278 lab=EN_A3_A}
C {ipin.sym} 7960 -3280 0 0 {name=p279 lab=EN_A3_PDRV1}
C {ipin.sym} 7960 -3260 0 0 {name=p280 lab=EN_A3_PDRV0}
C {ipin.sym} 7960 -3240 0 0 {name=p281 lab=EN_A3_PD}
C {ipin.sym} 7960 -3220 0 0 {name=p282 lab=EN_A3_PU}
C {opin.sym} 7960 -3200 2 0 {name=p283 lab=EN_A3_Y}
C {ipin.sym} 7960 -3180 0 0 {name=p284 lab=EN_A3_CS}
C {ipin.sym} 7960 -3160 0 0 {name=p285 lab=EN_A3_IE}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 8220 -4260 0 1 {name=IO_VDD3V3_A3
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 8200 -4440 2 1 {name=p221 lab=VDD3V3_A3}
C {short.sym} 8170 -4440 1 1 {name=x25 value=0.1}
C {short.sym} 7860 -4420 1 1 {name=x26 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 8220 -4000 0 1 {name=IO_VSS_1_A3
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 8220 -3980 2 1 {name=p222 lab=VSS_1_A3}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 8220 -1820 0 1 {name=IO_VSS_2_A3
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 8220 -1800 2 1 {name=p223 lab=VSS_2_A3}
C {ipin.sym} 8220 -5240 2 0 {name=p224 lab=EN_PAD}
C {Chipathon2025_pads/xschem/symbols/io_bi_t.sym} 8220 -5360 2 0 {name=IO_EN
model=gf180mcu_fd_io__bi_t
spiceprefix=X
}
C {ipin.sym} 7960 -5320 0 0 {name=p225 lab=EN_OE}
C {ipin.sym} 7960 -5300 0 0 {name=p226 lab=EN_SL}
C {ipin.sym} 7960 -5280 0 0 {name=p227 lab=EN_A}
C {ipin.sym} 7960 -5260 0 0 {name=p228 lab=EN_PDRV1}
C {ipin.sym} 7960 -5240 0 0 {name=p229 lab=EN_PDRV0}
C {ipin.sym} 7960 -5220 0 0 {name=p230 lab=EN_PD}
C {ipin.sym} 7960 -5200 0 0 {name=p235 lab=EN_PU}
C {opin.sym} 7960 -5180 2 0 {name=p236 lab=EN_Y}
C {ipin.sym} 7960 -5160 0 0 {name=p241 lab=EN_CS}
C {ipin.sym} 7960 -5140 0 0 {name=p242 lab=EN_IE}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 8220 -1420 0 1 {name=IO_VOUT_V_IF_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 8220 -1500 2 1 {name=p248 lab=VOUT_V_IF_A5_PAD}
C {iopin.sym} 8020 -1500 2 0 {name=p249 lab=VOUT_V_IF_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 7300 -320 3 0 {name=IO_I_BIAS_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 7220 -320 1 0 {name=p250 lab=I_BIAS_A5_PAD}
C {iopin.sym} 7220 -520 1 1 {name=p251 lab=I_BIAS_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 7040 -320 3 0 {name=IO_VIN_V_LOb_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 6960 -320 1 0 {name=p252 lab=VIN_V_LOb_A5_PAD}
C {iopin.sym} 6960 -520 1 1 {name=p253 lab=VIN_V_LOb_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 6780 -320 3 0 {name=IO_VIN_V_LO_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 6700 -320 1 0 {name=p254 lab=VIN_V_RFb_A5_PAD}
C {iopin.sym} 6700 -520 1 1 {name=p255 lab=VIN_V_RFb_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 6260 -320 3 0 {name=IO_VIN_V_RFb_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 6180 -320 1 0 {name=p256 lab=VIN_V_RF_A5_PAD}
C {iopin.sym} 6180 -520 1 1 {name=p257 lab=VIN_V_RF_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 6520 -320 3 0 {name=IO_VSS_A5
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 6540 -340 1 0 {name=p258 lab=VSS_A5}
C {short.sym} 6540 -370 2 0 {name=x24 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 6000 -320 3 0 {name=IO_VIN_V_RF_A5
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 5920 -320 1 0 {name=p259 lab=VIN_V_LO_A5_PAD}
C {iopin.sym} 5920 -520 1 1 {name=p260 lab=VIN_V_LO_A5_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvdd.sym} 2420 -320 3 0 {name=IO_VDD3V3_AXX
model=gf180mcu_fd_io__dvdd
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 2240 -340 1 0 {name=p261 lab=VDD3V3_AXX}
C {short.sym} 2240 -370 2 0 {name=x31 value=0.1}
C {short.sym} 2260 -680 2 0 {name=x32 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 2940 -320 3 0 {name=IO_VCOMP
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 2860 -320 1 0 {name=p262 lab=VCOMP_PAD}
C {iopin.sym} 2860 -520 1 1 {name=p263 lab=VCOMP_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 2680 -320 3 0 {name=IO_VREF12
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 2600 -320 1 0 {name=p264 lab=VREF12_PAD}
C {iopin.sym} 2600 -520 1 1 {name=p265 lab=VREF12_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_dvss.sym} 3200 -320 3 0 {name=IO_VSS_AXX
model=gf180mcu_fd_io__dvss
spiceprefix=X
spice_ignore=false
}
C {iopin.sym} 3220 -340 1 0 {name=p266 lab=VSS_AXX}
C {short.sym} 3220 -370 2 0 {name=x34 value=0.1}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 3720 -320 3 0 {name=IO_IOUTP_2UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 3640 -320 1 0 {name=p267 lab=IOUTP_2UA_PAD}
C {iopin.sym} 3640 -520 1 1 {name=p268 lab=IOUTP_2UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 3460 -320 3 0 {name=IO_IOUTN_2UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 3380 -320 1 0 {name=p269 lab=IOUTN_2UA_PAD}
C {iopin.sym} 3380 -520 1 1 {name=p270 lab=IOUTN_2UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 4240 -320 3 0 {name=IO_IOUTP_20UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4160 -320 1 0 {name=p286 lab=IOUTP_20UA_PAD}
C {iopin.sym} 4160 -520 1 1 {name=p287 lab=IOUTP_20UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 3980 -320 3 0 {name=IO_IOUTN_20UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 3900 -320 1 0 {name=p288 lab=IOUTN_20UA_PAD}
C {iopin.sym} 3900 -520 1 1 {name=p289 lab=IOUTN_20UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 4760 -320 3 0 {name=IO_IOUTP_50UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4680 -320 1 0 {name=p290 lab=IOUTP_50UA_PAD}
C {iopin.sym} 4680 -520 1 1 {name=p291 lab=IOUTP_50UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 4500 -320 3 0 {name=IO_IOUTN_50UA
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4420 -320 1 0 {name=p292 lab=IOUTN_50UA_PAD}
C {iopin.sym} 4420 -520 1 1 {name=p293 lab=IOUTN_50UA_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 5280 -320 3 0 {name=IO_VREFP_AXX
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 5200 -320 1 0 {name=p294 lab=VREFP_AXX_PAD}
C {iopin.sym} 5200 -520 1 1 {name=p295 lab=VREFP_AXX_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 5020 -320 3 0 {name=IO_VREFN_AXX
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4940 -320 1 0 {name=p296 lab=VREFN_AXX_PAD}
C {iopin.sym} 4940 -520 1 1 {name=p297 lab=VREFN_AXX_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 2100 -320 3 0 {name=IO_ana47
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 2020 -320 1 0 {name=p298 lab=ana47_PAD}
C {iopin.sym} 2020 -520 1 1 {name=p299 lab=ana47_ASIG5V}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 5600 -320 3 0 {name=IO_ana57
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 5520 -320 1 0 {name=p300 lab=ana57_PAD}
C {iopin.sym} 5520 -520 1 1 {name=p301 lab=ana57_ASIG5V}
C {iopin.sym} 7590 -7590 2 0 {name=p302 lab=VDD_A1}
C {iopin.sym} 7180 -7640 0 0 {name=p303 lab=VSS_A1}
C {iopin.sym} 4480 -7590 2 0 {name=p304 lab=LDO_OUT}
C {iopin.sym} 3160 -7590 2 0 {name=p305 lab=VTEST}
C {iopin.sym} 430 -6940 1 0 {name=p306 lab=AVDD_A2}
C {iopin.sym} 380 -6530 3 0 {name=p307 lab=AVSS_A2}
C {iopin.sym} 430 -1580 1 0 {name=p308 lab=VDD_A2}
C {iopin.sym} 1280 -540 2 0 {name=p309 lab=VSS_A2}
C {iopin.sym} 2260 -590 0 0 {name=p310 lab=VDD3V3_AXX}
C {iopin.sym} 3200 -540 2 0 {name=p311 lab=VSS_AXX}
C {iopin.sym} 6520 -540 2 0 {name=p312 lab=VSS_A5}
C {iopin.sym} 7950 -1320 3 1 {name=p313 lab=VDD3V3_A5}
C {iopin.sym} 8010 -1820 1 1 {name=p314 lab=VSS_2_A3}
C {iopin.sym} 8000 -4000 1 1 {name=p315 lab=VSS_1_A3}
C {iopin.sym} 7950 -4420 3 1 {name=p316 lab=VDD3V3_A3}
C {iopin.sym} 7950 -4730 3 1 {name=p317 lab=VDD_A4}
C {iopin.sym} 8000 -4840 1 1 {name=p318 lab=VSS_A4}
C {res.sym} 7180 -7590 0 0 {name=R_VSS_A1
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 430 -6530 3 0 {name=R_AVSS_A2
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 1280 -590 2 0 {name=R_VSS_A2
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 3200 -590 2 0 {name=R_VSS_AXX
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 6520 -590 2 0 {name=R_VSS_A5
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 7950 -1820 3 0 {name=R_VSS_2_A3
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 7950 -4000 3 0 {name=R_VSS_1_A3
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 7950 -4840 3 0 {name=R_VSS_A4
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 8180 -1800 3 0 {name=R_DVSS_2_A3
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 8180 -3980 3 0 {name=R_DVSS_1_A3
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {res.sym} 7860 -1800 3 0 {name=R_VSS_A3
value=1
footprint=1206
device=resistor
m=1
lvs_format="short"}
C {iopin.sym} 4710 -7860 3 0 {name=p319 lab=VCO_IBIAS_PAD}
C {Chipathon2025_pads/xschem/symbols/io_asig_5p0.sym} 4630 -7860 1 0 {name=IO_LDO_IBIAS1
model=gf180mcu_fd_io__asig_5p0
spiceprefix=X
}
C {iopin.sym} 4710 -7660 3 1 {name=p320 lab=VCO_IBIAS_ASIG5V}
