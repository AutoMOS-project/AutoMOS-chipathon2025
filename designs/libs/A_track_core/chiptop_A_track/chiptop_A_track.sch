v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
T {Axx TOP} 3030 -1870 0 0 5 5 {}
T {A1 TOP} 3480 -6820 0 0 5 5 {}
T {A3 TOP} 5660 -3050 0 0 5 5 {}
T {A5 TOP} 6290 -1380 0 0 5 5 {}
N 2740 -8140 2740 -8100 {lab=TEST_IBIAS_OVRD}
N 1140 -8140 1140 -8100 {lab=TEST_SEL_2}
N 1460 -8140 1460 -8100 {lab=TEST_SEL_1}
N 1780 -8140 1780 -8100 {lab=TEST_SEL_0}
N 2100 -8140 2100 -8100 {lab=TEST_EN}
N 2420 -8140 2420 -8100 {lab=TEST_IBIAS}
N 3060 -8140 3060 -8110 {lab=VTEST}
N 3060 -8110 3060 -8100 {lab=VTEST}
N 4660 -8140 4660 -8100 {lab=VCO_IBIAS}
N 4980 -8140 4980 -8100 {lab=VCO_IBIAS_OVRD}
N 820 -8140 820 -8100 {lab=TEST_OUT}
N 3380 -8140 3380 -8100 {lab=VCO_OUT}
N 3700 -8140 3700 -8100 {lab=VCO_EN}
N 4020 -8140 4020 -8100 {lab=VCO_IN}
N 4340 -8140 4340 -8100 {lab=LDO_OUT}
N 5300 -8140 5300 -8100 {lab=LDO_IBIAS}
N 5620 -8140 5620 -8100 {lab=LDO_IBIAS_OVRD}
N 5940 -8140 5940 -8100 {lab=LDO_VREF}
N 6260 -8140 6260 -8100 {lab=LDO_VREF_OVRD}
N 6580 -8140 6580 -8100 {lab=LDO_EN}
N 6900 -8140 6900 -8100 {lab=BIAS_EN}
N 7220 -8140 7220 -8100 {lab=VSS_A1}
N 7540 -8140 7540 -8100 {lab=VDD_A1}
N 4940 -7280 4940 -7140 {lab=VDD_A1}
N 4940 -7280 7540 -7280 {lab=VDD_A1}
N 7540 -7700 7540 -7280 {lab=VDD_A1}
N 7220 -7700 7220 -7300 {lab=VSS_A1}
N 6820 -7700 6820 -7680 {lab=#net1}
N 6820 -7680 6860 -7680 {lab=#net1}
N 6860 -7700 6860 -7680 {lab=#net1}
N 6900 -7700 6900 -7640 {lab=#net2}
N 6880 -7640 6900 -7640 {lab=#net2}
N 6880 -7700 6880 -7640 {lab=#net2}
N 6860 -7680 6980 -7680 {lab=#net1}
N 6980 -7700 6980 -7680 {lab=#net1}
N 6960 -7700 6960 -7680 {lab=#net1}
N 6940 -7700 6940 -7680 {lab=#net1}
N 6920 -7700 6920 -7680 {lab=#net1}
N 6820 -7460 6820 -7340 {lab=#net1}
N 6840 -7420 6840 -7320 {lab=#net2}
N 6840 -7640 6880 -7640 {lab=#net2}
N 4880 -7300 7220 -7300 {lab=VSS_A1}
N 4880 -7300 4880 -7140 {lab=VSS_A1}
N 6800 -7700 6800 -7360 {lab=#net3}
N 6820 -7680 6820 -7460 {lab=#net1}
N 6840 -7640 6840 -7420 {lab=#net2}
N 6500 -7700 6500 -7680 {lab=#net4}
N 6500 -7680 6540 -7680 {lab=#net4}
N 6540 -7700 6540 -7680 {lab=#net4}
N 6580 -7700 6580 -7640 {lab=#net5}
N 6560 -7640 6580 -7640 {lab=#net5}
N 6560 -7700 6560 -7640 {lab=#net5}
N 6540 -7680 6660 -7680 {lab=#net4}
N 6660 -7700 6660 -7680 {lab=#net4}
N 6640 -7700 6640 -7680 {lab=#net4}
N 6620 -7700 6620 -7680 {lab=#net4}
N 6600 -7700 6600 -7680 {lab=#net4}
N 6520 -7640 6560 -7640 {lab=#net5}
N 6480 -7700 6480 -7480 {lab=#net6}
N 6500 -7680 6500 -7460 {lab=#net4}
N 6520 -7640 6520 -7420 {lab=#net5}
N 6180 -7700 6180 -7680 {lab=#net7}
N 6180 -7680 6220 -7680 {lab=#net7}
N 6220 -7700 6220 -7680 {lab=#net7}
N 6260 -7700 6260 -7640 {lab=#net8}
N 6240 -7640 6260 -7640 {lab=#net8}
N 6240 -7700 6240 -7640 {lab=#net8}
N 6220 -7680 6340 -7680 {lab=#net7}
N 6340 -7700 6340 -7680 {lab=#net7}
N 6320 -7700 6320 -7680 {lab=#net7}
N 6300 -7700 6300 -7680 {lab=#net7}
N 6280 -7700 6280 -7680 {lab=#net7}
N 6200 -7640 6240 -7640 {lab=#net8}
N 6160 -7700 6160 -7480 {lab=#net9}
N 6180 -7680 6180 -7460 {lab=#net7}
N 6200 -7640 6200 -7440 {lab=#net8}
N 5540 -7700 5540 -7680 {lab=#net10}
N 5540 -7680 5580 -7680 {lab=#net10}
N 5580 -7700 5580 -7680 {lab=#net10}
N 5620 -7700 5620 -7640 {lab=#net11}
N 5600 -7640 5620 -7640 {lab=#net11}
N 5600 -7700 5600 -7640 {lab=#net11}
N 5580 -7680 5700 -7680 {lab=#net10}
N 5700 -7700 5700 -7680 {lab=#net10}
N 5680 -7700 5680 -7680 {lab=#net10}
N 5660 -7700 5660 -7680 {lab=#net10}
N 5640 -7700 5640 -7680 {lab=#net10}
N 5560 -7640 5600 -7640 {lab=#net11}
N 5520 -7700 5520 -7560 {lab=#net12}
N 5540 -7680 5540 -7540 {lab=#net10}
N 5560 -7640 5560 -7520 {lab=#net11}
N 4900 -7700 4900 -7680 {lab=#net13}
N 4900 -7680 4940 -7680 {lab=#net13}
N 4940 -7700 4940 -7680 {lab=#net13}
N 4980 -7700 4980 -7640 {lab=#net14}
N 4960 -7640 4980 -7640 {lab=#net14}
N 4960 -7700 4960 -7640 {lab=#net14}
N 4940 -7680 5060 -7680 {lab=#net13}
N 5060 -7700 5060 -7680 {lab=#net13}
N 5040 -7700 5040 -7680 {lab=#net13}
N 5020 -7700 5020 -7680 {lab=#net13}
N 5000 -7700 5000 -7680 {lab=#net13}
N 4920 -7640 4960 -7640 {lab=#net14}
N 4880 -7700 4880 -7640 {lab=#net15}
N 4900 -7680 4900 -7620 {lab=#net13}
N 4920 -7640 4920 -7600 {lab=#net14}
N 4800 -7320 6840 -7320 {lab=#net2}
N 4800 -7320 4800 -7140 {lab=#net2}
N 4780 -7340 6820 -7340 {lab=#net1}
N 4780 -7340 4780 -7140 {lab=#net1}
N 4820 -7360 6800 -7360 {lab=#net3}
N 4820 -7360 4820 -7140 {lab=#net3}
N 4200 -7660 4200 -7140 {lab=#net16}
N 4200 -7660 4660 -7660 {lab=#net16}
N 4660 -7700 4660 -7660 {lab=#net16}
N 4140 -7680 4140 -7140 {lab=LDO_OUT}
N 4140 -7680 4340 -7680 {lab=LDO_OUT}
N 4340 -7700 4340 -7680 {lab=LDO_OUT}
N 4080 -7680 4080 -7140 {lab=#net17}
N 4020 -7680 4080 -7680 {lab=#net17}
N 4020 -7700 4020 -7680 {lab=#net17}
N 3620 -7700 3620 -7680 {lab=#net18}
N 3620 -7680 3660 -7680 {lab=#net18}
N 3660 -7700 3660 -7680 {lab=#net18}
N 3660 -7680 3780 -7680 {lab=#net18}
N 3780 -7700 3780 -7680 {lab=#net18}
N 3760 -7700 3760 -7680 {lab=#net18}
N 3740 -7700 3740 -7680 {lab=#net18}
N 3720 -7700 3720 -7680 {lab=#net18}
N 3680 -7620 4000 -7620 {lab=#net19}
N 3600 -7700 3600 -7660 {lab=#net20}
N 4000 -7620 4000 -7140 {lab=#net19}
N 6520 -7420 6520 -7380 {lab=#net5}
N 4700 -7380 6520 -7380 {lab=#net5}
N 6500 -7460 6500 -7400 {lab=#net4}
N 4680 -7400 6500 -7400 {lab=#net4}
N 6480 -7480 6480 -7420 {lab=#net6}
N 4720 -7420 6480 -7420 {lab=#net6}
N 4300 -7640 4880 -7640 {lab=#net15}
N 4300 -7640 4300 -7140 {lab=#net15}
N 4260 -7620 4900 -7620 {lab=#net13}
N 4260 -7620 4260 -7140 {lab=#net13}
N 4280 -7600 4920 -7600 {lab=#net14}
N 4280 -7600 4280 -7140 {lab=#net14}
N 5300 -7700 5300 -7580 {lab=#net21}
N 4360 -7580 5300 -7580 {lab=#net21}
N 4360 -7580 4360 -7140 {lab=#net21}
N 4460 -7560 5520 -7560 {lab=#net12}
N 4460 -7560 4460 -7140 {lab=#net12}
N 4420 -7540 5540 -7540 {lab=#net10}
N 4420 -7540 4420 -7140 {lab=#net10}
N 4440 -7520 5560 -7520 {lab=#net11}
N 4440 -7520 4440 -7140 {lab=#net11}
N 5940 -7700 5940 -7500 {lab=#net22}
N 4520 -7500 5940 -7500 {lab=#net22}
N 4520 -7500 4520 -7140 {lab=#net22}
N 4620 -7480 6160 -7480 {lab=#net9}
N 4620 -7480 4620 -7140 {lab=#net9}
N 4580 -7460 6180 -7460 {lab=#net7}
N 4580 -7460 4580 -7140 {lab=#net7}
N 4600 -7440 6200 -7440 {lab=#net8}
N 4600 -7440 4600 -7140 {lab=#net8}
N 4680 -7400 4680 -7140 {lab=#net4}
N 4700 -7380 4700 -7140 {lab=#net5}
N 4720 -7420 4720 -7140 {lab=#net6}
N 3780 -7660 3980 -7660 {lab=#net18}
N 3980 -7660 3980 -7140 {lab=#net18}
N 3600 -7640 4020 -7640 {lab=#net20}
N 4020 -7640 4020 -7140 {lab=#net20}
N 3300 -7700 3300 -7660 {lab=#net23}
N 3340 -7700 3340 -7680 {lab=#net24}
N 3340 -7680 3460 -7680 {lab=#net24}
N 3460 -7700 3460 -7680 {lab=#net24}
N 3440 -7700 3440 -7680 {lab=#net24}
N 3420 -7700 3420 -7680 {lab=#net24}
N 3400 -7700 3400 -7680 {lab=#net24}
N 2660 -7700 2660 -7680 {lab=#net25}
N 2660 -7680 2700 -7680 {lab=#net25}
N 2700 -7700 2700 -7680 {lab=#net25}
N 2740 -7700 2740 -7640 {lab=#net26}
N 2720 -7640 2740 -7640 {lab=#net26}
N 2720 -7700 2720 -7640 {lab=#net26}
N 2700 -7680 2820 -7680 {lab=#net25}
N 2820 -7700 2820 -7680 {lab=#net25}
N 2800 -7700 2800 -7680 {lab=#net25}
N 2780 -7700 2780 -7680 {lab=#net25}
N 2760 -7700 2760 -7680 {lab=#net25}
N 2640 -7700 2640 -7660 {lab=#net27}
N 2020 -7700 2020 -7680 {lab=#net28}
N 2020 -7680 2060 -7680 {lab=#net28}
N 2060 -7700 2060 -7680 {lab=#net28}
N 2100 -7700 2100 -7640 {lab=#net29}
N 2080 -7640 2100 -7640 {lab=#net29}
N 2080 -7700 2080 -7640 {lab=#net29}
N 2060 -7680 2180 -7680 {lab=#net28}
N 2180 -7700 2180 -7680 {lab=#net28}
N 2160 -7700 2160 -7680 {lab=#net28}
N 2140 -7700 2140 -7680 {lab=#net28}
N 2120 -7700 2120 -7680 {lab=#net28}
N 2000 -7700 2000 -7660 {lab=#net30}
N 1700 -7700 1700 -7680 {lab=#net31}
N 1700 -7680 1740 -7680 {lab=#net31}
N 1740 -7700 1740 -7680 {lab=#net31}
N 1780 -7700 1780 -7640 {lab=#net32}
N 1760 -7640 1780 -7640 {lab=#net32}
N 1760 -7700 1760 -7640 {lab=#net32}
N 1740 -7680 1860 -7680 {lab=#net31}
N 1860 -7700 1860 -7680 {lab=#net31}
N 1840 -7700 1840 -7680 {lab=#net31}
N 1820 -7700 1820 -7680 {lab=#net31}
N 1800 -7700 1800 -7680 {lab=#net31}
N 1680 -7700 1680 -7660 {lab=#net33}
N 1380 -7700 1380 -7680 {lab=#net34}
N 1380 -7680 1420 -7680 {lab=#net34}
N 1420 -7700 1420 -7680 {lab=#net34}
N 1460 -7700 1460 -7640 {lab=#net35}
N 1440 -7640 1460 -7640 {lab=#net35}
N 1440 -7700 1440 -7640 {lab=#net35}
N 1420 -7680 1540 -7680 {lab=#net34}
N 1540 -7700 1540 -7680 {lab=#net34}
N 1520 -7700 1520 -7680 {lab=#net34}
N 1500 -7700 1500 -7680 {lab=#net34}
N 1480 -7700 1480 -7680 {lab=#net34}
N 1360 -7700 1360 -7660 {lab=#net36}
N 1060 -7700 1060 -7680 {lab=#net37}
N 1060 -7680 1100 -7680 {lab=#net37}
N 1100 -7700 1100 -7680 {lab=#net37}
N 1140 -7700 1140 -7640 {lab=#net38}
N 1120 -7640 1140 -7640 {lab=#net38}
N 1120 -7700 1120 -7640 {lab=#net38}
N 1100 -7680 1220 -7680 {lab=#net37}
N 1220 -7700 1220 -7680 {lab=#net37}
N 1200 -7700 1200 -7680 {lab=#net37}
N 1180 -7700 1180 -7680 {lab=#net37}
N 1160 -7700 1160 -7680 {lab=#net37}
N 1040 -7700 1040 -7660 {lab=#net39}
N 3360 -7700 3360 -7680 {lab=#net24}
N 3380 -7700 3380 -7680 {lab=#net24}
N 3320 -7700 3320 -7640 {lab=#net40}
N 3680 -7700 3680 -7620 {lab=#net19}
N 3700 -7700 3700 -7620 {lab=#net19}
N 3780 -7680 3780 -7660 {lab=#net18}
N 3600 -7660 3600 -7640 {lab=#net20}
N 3320 -7640 3320 -7600 {lab=#net40}
N 3320 -7600 3920 -7600 {lab=#net40}
N 3920 -7600 3920 -7140 {lab=#net40}
N 3300 -7660 3300 -7580 {lab=#net23}
N 3300 -7580 3900 -7580 {lab=#net23}
N 3900 -7580 3900 -7140 {lab=#net23}
N 3340 -7680 3340 -7560 {lab=#net24}
N 3340 -7560 3880 -7560 {lab=#net24}
N 3880 -7560 3880 -7140 {lab=#net24}
N 3060 -7700 3060 -7540 {lab=VTEST}
N 3060 -7540 3810 -7540 {lab=VTEST}
N 3810 -7540 3820 -7540 {lab=VTEST}
N 3820 -7540 3820 -7140 {lab=VTEST}
N 2640 -7660 2640 -7520 {lab=#net27}
N 2640 -7520 3760 -7520 {lab=#net27}
N 3760 -7520 3760 -7140 {lab=#net27}
N 2720 -7640 2720 -7500 {lab=#net26}
N 2720 -7500 3740 -7500 {lab=#net26}
N 3740 -7500 3740 -7140 {lab=#net26}
N 2660 -7680 2660 -7480 {lab=#net25}
N 2660 -7480 3720 -7480 {lab=#net25}
N 3720 -7480 3720 -7140 {lab=#net25}
N 2420 -7710 2420 -7460 {lab=#net41}
N 2420 -7460 3660 -7460 {lab=#net41}
N 3660 -7460 3660 -7140 {lab=#net41}
N 2000 -7660 2000 -7440 {lab=#net30}
N 2000 -7440 3600 -7440 {lab=#net30}
N 3600 -7440 3600 -7140 {lab=#net30}
N 2080 -7640 2080 -7420 {lab=#net29}
N 2080 -7420 3580 -7420 {lab=#net29}
N 3580 -7420 3580 -7140 {lab=#net29}
N 2020 -7680 2020 -7400 {lab=#net28}
N 2020 -7400 3560 -7400 {lab=#net28}
N 3560 -7400 3560 -7140 {lab=#net28}
N 1680 -7660 1680 -7380 {lab=#net33}
N 1680 -7380 3500 -7380 {lab=#net33}
N 3500 -7380 3500 -7140 {lab=#net33}
N 1760 -7640 1760 -7360 {lab=#net32}
N 1760 -7360 3480 -7360 {lab=#net32}
N 3480 -7360 3480 -7140 {lab=#net32}
N 1700 -7680 1700 -7340 {lab=#net31}
N 1700 -7340 3460 -7340 {lab=#net31}
N 3460 -7340 3460 -7140 {lab=#net31}
N 1360 -7660 1360 -7320 {lab=#net36}
N 1360 -7320 3400 -7320 {lab=#net36}
N 3400 -7320 3400 -7140 {lab=#net36}
N 1440 -7640 1440 -7300 {lab=#net35}
N 1440 -7300 3380 -7300 {lab=#net35}
N 3380 -7300 3380 -7140 {lab=#net35}
N 1380 -7680 1380 -7280 {lab=#net34}
N 1380 -7280 3360 -7280 {lab=#net34}
N 3360 -7280 3360 -7140 {lab=#net34}
N 1040 -7660 1040 -7260 {lab=#net39}
N 1040 -7260 3300 -7260 {lab=#net39}
N 3300 -7260 3300 -7140 {lab=#net39}
N 1120 -7640 1120 -7240 {lab=#net38}
N 1120 -7240 3280 -7240 {lab=#net38}
N 3280 -7240 3280 -7140 {lab=#net38}
N 1060 -7680 1060 -7220 {lab=#net37}
N 1060 -7220 3260 -7220 {lab=#net37}
N 3260 -7220 3260 -7140 {lab=#net37}
N 820 -7700 820 -7200 {lab=#net42}
N 3200 -7200 3200 -7140 {lab=#net42}
N 820 -7200 3200 -7200 {lab=#net42}
N 660 -740 680 -740 {lab=#net43}
N 680 -780 680 -740 {lab=#net43}
N 660 -780 680 -780 {lab=#net43}
N 680 -900 680 -780 {lab=#net43}
N 660 -900 680 -900 {lab=#net43}
N 660 -880 680 -880 {lab=#net43}
N 660 -860 680 -860 {lab=#net43}
N 660 -840 680 -840 {lab=#net43}
N 660 -720 700 -720 {lab=#net44}
N 660 -800 740 -800 {lab=#net45}
N 660 -820 740 -820 {lab=#net45}
N 680 -900 700 -900 {lab=#net43}
N 1220 -680 1220 -660 {lab=#net46}
N 1180 -680 1220 -680 {lab=#net46}
N 1180 -680 1180 -660 {lab=#net46}
N 1060 -680 1180 -680 {lab=#net46}
N 1060 -680 1060 -660 {lab=#net46}
N 1080 -680 1080 -660 {lab=#net46}
N 1100 -680 1100 -660 {lab=#net46}
N 1120 -680 1120 -660 {lab=#net46}
N 1240 -700 1240 -660 {lab=#net47}
N 1160 -740 1160 -660 {lab=#net48}
N 1140 -740 1140 -660 {lab=#net48}
N 1060 -700 1060 -680 {lab=#net46}
N 740 -820 740 -800 {lab=#net45}
N 1140 -740 1160 -740 {lab=#net48}
N 3170 -1130 3170 -1080 {lab=VDD3V3_AXX}
N 1780 -1080 3170 -1080 {lab=VDD3V3_AXX}
N 1780 -1080 1780 -660 {lab=VDD3V3_AXX}
N 2100 -1020 2100 -660 {lab=#net49}
N 2100 -1020 3230 -1020 {lab=#net49}
N 3230 -1130 3230 -1020 {lab=#net49}
N 3290 -1130 3290 -960 {lab=#net50}
N 2420 -960 3290 -960 {lab=#net50}
N 2420 -960 2420 -660 {lab=#net50}
N 3350 -1130 3350 -900 {lab=VSS_AXX}
N 2740 -900 3350 -900 {lab=VSS_AXX}
N 2740 -900 2740 -660 {lab=VSS_AXX}
N 3410 -1130 3410 -840 {lab=#net51}
N 3060 -840 3410 -840 {lab=#net51}
N 3060 -840 3060 -660 {lab=#net51}
N 3470 -1130 3470 -780 {lab=#net52}
N 3380 -780 3470 -780 {lab=#net52}
N 3380 -780 3380 -660 {lab=#net52}
N 3530 -1130 3530 -780 {lab=#net53}
N 3530 -780 3700 -780 {lab=#net53}
N 3700 -780 3700 -660 {lab=#net53}
N 3590 -1130 3590 -840 {lab=#net54}
N 3590 -840 4020 -840 {lab=#net54}
N 4020 -840 4020 -660 {lab=#net54}
N 3650 -1130 3650 -900 {lab=#net55}
N 3650 -900 4340 -900 {lab=#net55}
N 4340 -900 4340 -660 {lab=#net55}
N 3710 -1130 3710 -960 {lab=#net56}
N 3710 -960 4660 -960 {lab=#net56}
N 4660 -960 4660 -660 {lab=#net56}
N 3770 -1130 3770 -1020 {lab=#net57}
N 3770 -1020 4980 -1020 {lab=#net57}
N 4980 -1020 4980 -660 {lab=#net57}
N 3830 -1130 3830 -1080 {lab=#net57}
N 3830 -1080 5300 -1080 {lab=#net57}
N 5300 -1080 5300 -660 {lab=#net57}
N 1460 -700 1460 -660 {lab=#net58}
N 5620 -700 5620 -660 {lab=#net59}
N 6990 -3020 7020 -3020 {lab=VDD3V3_A3}
N 7020 -4340 7020 -3020 {lab=VDD3V3_A3}
N 7020 -4340 7700 -4340 {lab=VDD3V3_A3}
N 7080 -4020 7700 -4020 {lab=VSS_2_A3}
N 7080 -4020 7080 -3000 {lab=VSS_2_A3}
N 6990 -3000 7080 -3000 {lab=VSS_2_A3}
N 6990 -2970 7140 -2970 {lab=#net60}
N 7140 -3700 7140 -2970 {lab=#net60}
N 7140 -3700 7700 -3700 {lab=#net60}
N 7060 -1780 7700 -1780 {lab=#net61}
N 6990 -2780 7020 -2780 {lab=#net61}
N 7020 -2780 7020 -1780 {lab=#net61}
N 7020 -1780 7060 -1780 {lab=#net61}
N 6990 -2800 7080 -2800 {lab=#net62}
N 7080 -2800 7080 -2100 {lab=#net62}
N 7080 -2100 7700 -2100 {lab=#net62}
N 6990 -2820 7140 -2820 {lab=#net63}
N 7140 -2820 7140 -2420 {lab=#net63}
N 7140 -2420 7700 -2420 {lab=#net63}
N 6990 -2950 7200 -2950 {lab=#net64}
N 7200 -3380 7200 -2950 {lab=#net64}
N 7200 -3380 7700 -3380 {lab=#net64}
N 6990 -2920 7260 -2920 {lab=#net65}
N 7260 -3150 7260 -2920 {lab=#net65}
N 7260 -3150 7700 -3150 {lab=#net65}
N 6990 -2840 7200 -2840 {lab=#net66}
N 7200 -2840 7200 -2740 {lab=#net66}
N 7200 -2740 7700 -2740 {lab=#net66}
N 6990 -2900 7320 -2900 {lab=#net67}
N 6990 -2880 7380 -2880 {lab=#net68}
N 7380 -3040 7380 -2880 {lab=#net68}
N 7380 -3040 7620 -3040 {lab=#net68}
N 7660 -3050 7700 -3050 {lab=#net67}
N 7660 -3070 7660 -3050 {lab=#net67}
N 7660 -3070 7700 -3070 {lab=#net67}
N 7320 -3070 7660 -3070 {lab=#net67}
N 7320 -3070 7320 -2900 {lab=#net67}
N 7620 -3130 7620 -3040 {lab=#net68}
N 7620 -3130 7700 -3130 {lab=#net68}
N 7620 -3110 7700 -3110 {lab=#net68}
N 7620 -3090 7700 -3090 {lab=#net68}
N 7620 -3030 7700 -3030 {lab=#net68}
N 7620 -3040 7620 -3030 {lab=#net68}
N 7620 -3010 7700 -3010 {lab=#net68}
N 7620 -3030 7620 -3010 {lab=#net68}
N 7620 -2990 7700 -2990 {lab=#net68}
N 7620 -3010 7620 -2990 {lab=#net68}
N 7620 -2970 7700 -2970 {lab=#net68}
N 7620 -2990 7620 -2970 {lab=#net68}
N 6820 -1460 7700 -1460 {lab=VSS_2_A3}
N 6820 -3100 6820 -1460 {lab=VSS_2_A3}
N 6820 -3100 7080 -3100 {lab=VSS_2_A3}
N 1460 -260 1460 -200 {lab=ana47}
N 1780 -260 1780 -200 {lab=VDD3V3_AXX}
N 2100 -260 2100 -200 {lab=VREF12}
N 2420 -260 2420 -200 {lab=VCOMP}
N 2740 -260 2740 -200 {lab=VSS_AXX}
N 3060 -260 3060 -200 {lab=IOUTN_2UA}
N 3380 -260 3380 -200 {lab=IOUTP_2UA}
N 3700 -260 3700 -200 {lab=IOUTN_20UA}
N 4020 -260 4020 -200 {lab=IOUTP_20UA}
N 4340 -260 4340 -200 {lab=IOUTN_50UA}
N 4660 -260 4660 -200 {lab=IOUTP_50UA}
N 4980 -260 4980 -200 {lab=VREFN_AXX}
N 5300 -260 5300 -200 {lab=VREFN_AXX}
N 5620 -260 5620 -200 {lab=ana57}
N 6640 -970 6640 -900 {lab=#net69}
N 5940 -900 6640 -900 {lab=#net69}
N 5940 -900 5940 -660 {lab=#net69}
N 6260 -880 6260 -660 {lab=#net70}
N 6260 -880 6680 -880 {lab=#net70}
N 6680 -970 6680 -880 {lab=#net70}
N 6730 -970 6730 -860 {lab=VSS_A5}
N 6580 -860 6730 -860 {lab=VSS_A5}
N 6580 -860 6580 -660 {lab=VSS_A5}
N 6780 -970 6780 -860 {lab=#net71}
N 6780 -860 6900 -860 {lab=#net71}
N 6900 -860 6900 -660 {lab=#net71}
N 6820 -970 6820 -880 {lab=#net72}
N 6820 -880 7220 -880 {lab=#net72}
N 7220 -880 7220 -660 {lab=#net72}
N 6850 -970 6850 -900 {lab=#net73}
N 6850 -900 7540 -900 {lab=#net73}
N 7540 -900 7540 -660 {lab=#net73}
N 6880 -1000 7620 -1000 {lab=VDD3V3_A5}
N 7620 -1000 7620 -820 {lab=VDD3V3_A5}
N 7620 -820 7700 -820 {lab=VDD3V3_A5}
N 7620 -1140 7690 -1140 {lab=#net74}
N 7620 -1140 7620 -1030 {lab=#net74}
N 6880 -1030 7620 -1030 {lab=#net74}
N 7690 -1140 7700 -1140 {lab=#net74}
N 5940 -260 5940 -200 {lab=VIN_V_LO_A5}
N 6260 -260 6260 -200 {lab=VIN_V_RF_A5}
N 6580 -260 6580 -200 {lab=VSS_A5}
N 6900 -260 6900 -200 {lab=VIN_V_RFb_A5}
N 7220 -260 7220 -200 {lab=VIN_V_LOb_A5}
N 7540 -260 7540 -200 {lab=I_BIAS_A5}
N 8120 -820 8180 -820 {lab=VDD3V3_A5}
N 8120 -1140 8180 -1140 {lab=VOUT_V_IF_A5}
N 8120 -1460 8180 -1460 {lab=VSS_2_A3}
N 8120 -1780 8180 -1780 {lab=VCM_OUT_A3}
N 8120 -2100 8180 -2100 {lab=BCM_OUT_A3}
N 8120 -2420 8180 -2420 {lab=CCM_OUT_A3}
N 8120 -2740 8180 -2740 {lab=V_BIAS_EN_A3}
N 8120 -3060 8180 -3060 {lab=EN_A3}
N 8120 -3380 8180 -3380 {lab=V_AUX_A3}
N 8120 -3700 8180 -3700 {lab=V_IN_A3}
N 8120 -4020 8180 -4020 {lab=VSS_2_A3}
N 8120 -4340 8180 -4340 {lab=VDD3V3_A3}
N 8120 -4680 8180 -4680 {lab=VDD_A4}
N 8120 -4980 8180 -4980 {lab=VSS_A4}
N 8120 -5300 8180 -5300 {lab=EN}
N 8120 -5620 8180 -5620 {lab=VREF}
N 8120 -5950 8180 -5950 {lab=VCTRL}
N 8120 -6260 8180 -6260 {lab=IBIAS}
N 8120 -6580 8180 -6580 {lab=VOUT0}
N 8120 -6910 8180 -6910 {lab=VOUT90}
N 8120 -7220 8180 -7220 {lab=VOUT180}
N 8120 -7550 8180 -7550 {lab=VOUT270}
N 1140 -260 1140 -200 {lab=RST_N_A2}
N 200 -820 260 -820 {lab=CLK_IN_A2}
N 810 -260 810 -200 {lab=VSS_A2}
N 200 -1130 260 -1130 {lab=VDD_A2}
N 200 -1480 260 -1480 {lab=ana47}
N 200 -1790 260 -1790 {lab=ana47}
N 200 -2110 260 -2110 {lab=ana47}
N 200 -2430 260 -2430 {lab=ana47}
N 200 -2750 260 -2750 {lab=ana47}
N 200 -3060 260 -3060 {lab=ana47}
N 200 -3380 260 -3380 {lab=ana47}
N 200 -3700 260 -3700 {lab=ana47}
N 200 -4020 260 -4020 {lab=ana47}
N 200 -4340 260 -4340 {lab=ana47}
N 200 -4660 260 -4660 {lab=ana47}
N 200 -4980 260 -4980 {lab=ana47}
N 200 -5300 260 -5300 {lab=ana47}
N 200 -5620 260 -5620 {lab=ana47}
N 200 -5950 260 -5950 {lab=ana47}
N 200 -6260 260 -6260 {lab=ana47}
N 200 -6580 260 -6580 {lab=VBIAS_A2}
N 200 -6900 260 -6900 {lab=VCM_A2}
N 200 -7210 260 -7210 {lab=AVSS_A2}
N 200 -7540 260 -7540 {lab=AVDD_A2}
C {libs/A1_core/A1_top/A1_top.sym} 3160 -6880 0 0 {name=xI_top}
C {libs/A_track_core/padring/padring.sym} 280 -280 0 0 {name=xI_top_io
lock=true}
C {iopin.sym} 3380 -8140 3 0 { name=p48 lab=VCO_OUT }
C {iopin.sym} 4020 -8140 1 1 { name=p49 lab=VCO_IN }
C {ipin.sym} 4980 -8140 1 0 { name=p50 lab=VCO_IBIAS_OVRD }
C {iopin.sym} 4660 -8140 1 1 { name=p51 lab=VCO_IBIAS }
C {ipin.sym} 3700 -8140 1 0 { name=p52 lab=VCO_EN }
C {ipin.sym} 1140 -8140 1 0 { name=p53 lab=TEST_SEL_2 }
C {ipin.sym} 1460 -8140 1 0 { name=p54 lab=TEST_SEL_1 }
C {ipin.sym} 1780 -8140 1 0 { name=p55 lab=TEST_SEL_0 }
C {iopin.sym} 820 -8140 3 0 { name=p56 lab=TEST_OUT }
C {ipin.sym} 2740 -8140 1 0 { name=p57 lab=TEST_IBIAS_OVRD }
C {iopin.sym} 2420 -8140 1 1 { name=p58 lab=TEST_IBIAS }
C {ipin.sym} 2100 -8140 1 0 { name=p59 lab=TEST_EN }
C {ipin.sym} 6260 -8140 1 0 { name=p61 lab=LDO_VREF_OVRD }
C {iopin.sym} 5940 -8140 1 1 { name=p62 lab=LDO_VREF }
C {ipin.sym} 5620 -8140 1 0 { name=p63 lab=LDO_IBIAS_OVRD }
C {iopin.sym} 5300 -8140 1 1 { name=p64 lab=LDO_IBIAS }
C {ipin.sym} 6580 -8140 1 0 { name=p65 lab=LDO_EN }
C {iopin.sym} 3060 -8140 1 1 { name=p66 lab=VTEST }
C {iopin.sym} 7220 -8140 3 0 { name=p67 lab=VSS_A1 }
C {iopin.sym} 7540 -8140 3 0 { name=p68 lab=VDD_A1 }
C {iopin.sym} 4340 -8140 3 0 { name=p69 lab=LDO_OUT }
C {ipin.sym} 6900 -8140 1 0 { name=p70 lab=BIAS_EN }
C {noconn.sym} 3280 -7700 3 0 {name=l1}
C {noconn.sym} 3640 -7700 3 0 {name=l2}
C {noconn.sym} 2680 -7700 3 0 {name=l3}
C {noconn.sym} 2040 -7700 3 0 {name=l4}
C {noconn.sym} 1720 -7700 3 0 {name=l5}
C {noconn.sym} 1400 -7700 3 0 {name=l6}
C {noconn.sym} 1080 -7700 3 0 {name=l7}
C {noconn.sym} 4920 -7700 3 0 {name=l8}
C {noconn.sym} 5560 -7700 3 0 {name=l9}
C {noconn.sym} 6200 -7700 3 0 {name=l10}
C {noconn.sym} 6520 -7700 3 0 {name=l11}
C {noconn.sym} 6840 -7700 3 0 {name=l12}
C {noconn.sym} 660 -760 2 0 {name=l13}
C {noconn.sym} 700 -900 2 0 {name=l14}
C {noconn.sym} 700 -720 2 0 {name=l15}
C {noconn.sym} 740 -820 2 0 {name=l16}
C {noconn.sym} 1060 -700 1 0 {name=l17}
C {noconn.sym} 1140 -740 1 0 {name=l18}
C {noconn.sym} 1240 -700 1 0 {name=l19}
C {noconn.sym} 1200 -660 1 0 {name=l20}
C {libs/Axx_core/Axx_top/Axx_top.sym} 3500 -1150 0 0 {name=x1}
C {noconn.sym} 1460 -700 1 0 {name=l23}
C {noconn.sym} 5620 -700 1 0 {name=l24}
C {libs/A3_core/A3_top/A3_top.sym} 6920 -2900 0 0 {name=x2}
C {libs/A5_core/A5_top/A5_top_level.sym} 6730 -1060 0 0 {name=x3}
C {iopin.sym} 1460 -200 3 1 { name=p1 lab=ana47}
C {iopin.sym} 1780 -200 3 1 { name=p2 lab=VDD3V3_AXX }
C {iopin.sym} 2100 -200 3 1 { name=p3 lab=VREF12 }
C {iopin.sym} 2420 -200 3 1 { name=p4 lab=VCOMP }
C {iopin.sym} 2740 -200 3 1 { name=p5 lab=VSS_AXX }
C {iopin.sym} 3060 -200 3 1 { name=p6 lab=IOUTN_2UA }
C {iopin.sym} 3380 -200 3 1 { name=p7 lab=IOUTP_2UA }
C {iopin.sym} 3700 -200 3 1 { name=p8 lab=IOUTN_20UA }
C {iopin.sym} 4020 -200 3 1 { name=p9 lab=IOUTP_20UA }
C {iopin.sym} 4340 -200 3 1 { name=p10 lab=IOUTN_50UA }
C {iopin.sym} 4660 -200 3 1 { name=p11 lab=IOUTP_50UA }
C {iopin.sym} 4980 -200 3 1 { name=p12 lab=VREFN_AXX }
C {iopin.sym} 5300 -200 3 1 { name=p13 lab=VREFP_AXX }
C {iopin.sym} 5620 -200 3 1 { name=p14 lab=ana57 }
C {iopin.sym} 5940 -200 3 1 { name=p15 lab=VIN_V_LO_A5 }
C {iopin.sym} 6260 -200 3 1 { name=p16 lab=VIN_V_RF_A5 }
C {iopin.sym} 6580 -200 3 1 { name=p17 lab=VSS_A5 }
C {iopin.sym} 6900 -200 3 1 { name=p18 lab=VIN_V_RFb_A5 }
C {iopin.sym} 7220 -200 3 1 { name=p19 lab=VIN_V_LOb_A5 }
C {iopin.sym} 7540 -200 3 1 { name=p20 lab=I_BIAS_A5 }
C {iopin.sym} 8180 -820 2 1 { name=p21 lab=VDD3V3_A5 }
C {iopin.sym} 8180 -1140 2 1 { name=p22 lab=VOUT_V_IF_A5 }
C {iopin.sym} 8180 -1460 2 1 { name=p23 lab=VSS_2_A3 }
C {iopin.sym} 8180 -1780 2 1 { name=p24 lab=VCM_OUT_A3 }
C {iopin.sym} 8180 -2100 2 1 { name=p25 lab=BCM_OUT_A3 }
C {iopin.sym} 8180 -2420 2 1 { name=p26 lab=CCM_OUT_A3 }
C {iopin.sym} 8180 -2740 2 1 { name=p27 lab=V_BIAS_EN_A3 }
C {ipin.sym} 8180 -3060 0 1 { name=p28 lab=EN_A3 }
C {iopin.sym} 8180 -3380 2 1 { name=p29 lab=V_AUX_A3 }
C {iopin.sym} 8180 -3700 2 1 { name=p30 lab=V_IN_A3 }
C {iopin.sym} 8180 -4020 2 1 { name=p31 lab=VSS_1_A3 }
C {iopin.sym} 8180 -4340 2 1 { name=p32 lab=VDD3V3_A3 }
C {iopin.sym} 8180 -4680 2 1 { name=p33 lab=VDD_A4 }
C {iopin.sym} 8180 -4980 2 1 { name=p34 lab=VSS_A4 }
C {ipin.sym} 8180 -5300 0 1 { name=p35 lab=EN }
C {iopin.sym} 8180 -5620 2 1 { name=p36 lab=VREF }
C {iopin.sym} 8180 -5950 2 1 { name=p37 lab=VCTRL }
C {iopin.sym} 8180 -6260 2 1 { name=p38 lab=IBIAS }
C {iopin.sym} 8180 -6580 2 1 { name=p39 lab=VOUT0 }
C {iopin.sym} 8180 -6910 2 1 { name=p40 lab=VOUT90 }
C {iopin.sym} 8180 -7220 2 1 { name=p41 lab=VOUT180 
}
C {iopin.sym} 8180 -7550 2 1 { name=p42 lab=VOUT270 }
C {ipin.sym} 1140 -200 1 1 { name=p43 lab=RST_N_A2 }
C {ipin.sym} 200 -820 2 1 { name=p44 lab=CLK_IN_A2 }
C {iopin.sym} 810 -200 3 1 { name=p45 lab=VSS_A2
}
C {iopin.sym} 200 -1130 0 1 { name=p46 lab=VDD_A2}
C {iopin.sym} 200 -1480 0 1 { name=p47 lab=OUT4N_A2}
C {iopin.sym} 200 -1790 0 1 { name=p60 lab=OUT4P_A2}
C {iopin.sym} 200 -2110 0 1 { name=p71 lab=OUT3N_A2}
C {iopin.sym} 200 -2430 0 1 { name=p72 lab=OUT3P_A2}
C {iopin.sym} 200 -2750 0 1 { name=p73 lab=OUT2N_A2}
C {iopin.sym} 200 -3060 0 1 { name=p74 lab=OUT2P_A2}
C {iopin.sym} 200 -3380 0 1 { name=p75 lab=OUT1N_A2}
C {iopin.sym} 200 -3700 0 1 { name=p76 lab=OUT1P_A2}
C {iopin.sym} 200 -4020 0 1 { name=p77 lab=IN4N_A2}
C {iopin.sym} 200 -4340 0 1 { name=p78 lab=IN4P_A2}
C {iopin.sym} 200 -4660 0 1 { name=p79 lab=IN3N_A2}
C {iopin.sym} 200 -4980 0 1 { name=p80 lab=IN3P_A2}
C {iopin.sym} 200 -5300 0 1 { name=p81 lab=IN2N_A2}
C {iopin.sym} 200 -5620 0 1 { name=p82 lab=IN2P_A2}
C {iopin.sym} 200 -5950 0 1 { name=p83 lab=IN1N_A2}
C {iopin.sym} 200 -6260 0 1 { name=p84 lab=IN1P_A2}
C {iopin.sym} 200 -6580 0 1 { name=p85 lab=VBIAS_A2}
C {iopin.sym} 200 -6900 0 1 { name=p86 lab=VCM_A2}
C {iopin.sym} 200 -7210 0 1 { name=p87 lab=AVSS_A2}
C {iopin.sym} 200 -7540 0 1 { name=p88 lab=AVDD_A2}
