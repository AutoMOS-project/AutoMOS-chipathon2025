v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_top/top/top.sym} 80 -210 0 0 {name=I_TOP}
C {lab_pin.sym} 180 -230 0 1 {name=p1 lab=VDD}
C {lab_pin.sym} 60 -190 0 0 {name=p2 lab=VCO_IN}
C {lab_pin.sym} 300 -190 0 1 {name=p3 lab=VOUT}
C {lab_pin.sym} 300 -170 0 1 {name=p4 lab=VCO_OUT}
C {lab_pin.sym} 60 -170 0 0 {name=p5 lab=VCO_EN}
C {lab_pin.sym} 300 -150 0 1 {name=p6 lab=TEST_OUT}
C {lab_pin.sym} 60 -150 0 0 {name=p7 lab=TEST_EN}
C {lab_pin.sym} 60 -130 0 0 {name=p8 lab=TEST_SEL[2:0]}
C {lab_pin.sym} 220 -70 1 1 {name=p9 lab=SUB}
C {lab_pin.sym} 180 -70 1 1 {name=p10 lab=VSS}
