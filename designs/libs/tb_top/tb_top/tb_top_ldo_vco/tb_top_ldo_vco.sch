v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_ldo/ldo/ldo/ldo.sym} 690 -410 0 0 {name=x1}
