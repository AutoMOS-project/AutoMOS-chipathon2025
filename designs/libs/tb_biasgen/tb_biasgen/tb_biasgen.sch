v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
C {libs/core_biasgen/biasgen/biasgen.sym} 70 -140 0 0 {name=I_biasgen}
C {lab_pin.sym} 150 -160 0 1 {name=p1 lab=VDD}
C {lab_pin.sym} 50 -100 0 0 {name=p2 lab=VBG}
C {lab_pin.sym} 290 -120 0 1 {name=p3 lab=IPTAT[2:0]}
C {lab_pin.sym} 290 -100 0 1 {name=p4 lab=IZTC[2:0]}
C {lab_pin.sym} 50 -60 0 0 {name=p5 lab=IPTAT_IN}
C {lab_pin.sym} 290 -60 0 1 {name=p6 lab=VREF_1V}
C {lab_pin.sym} 50 -40 0 0 {name=p7 lab=IZTC_IN}
C {lab_pin.sym} 290 -40 0 1 {name=p8 lab=VREF_0P5V}
C {lab_pin.sym} 170 0 1 1 {name=p9 lab=SUB}
C {lab_pin.sym} 150 0 1 1 {name=p10 lab=VSS}
