v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 130 -20 130 0 {lab=SUB}
C {iopin.sym} 80 -360 3 0 {name=p1 lab=VDD}
C {iopin.sym} 80 0 1 0 {name=p2 lab=VSS}
C {iopin.sym} 130 0 1 0 {name=p3 lab=SUB}
C {noconn.sym} 130 -20 0 0 {name=l1}
C {iopin.sym} 250 -120 0 0 {name=p4 lab=VOUT}
C {iopin.sym} 20 -320 2 0 {name=p6 lab=IBIAS}
C {ipin.sym} 20 -100 0 0 {name=p5 lab=EN}
C {ipin.sym} 20 -40 0 0 {name=p7 lab=SEL[2:0]}
C {iopin.sym} 20 -280 2 0 {name=p8 lab=IN0}
C {iopin.sym} 20 -260 2 0 {name=p9 lab=IN1
}
C {iopin.sym} 20 -240 2 0 {name=p10 lab=IN2}
C {iopin.sym} 20 -220 2 0 {name=p11 lab=IN3}
C {iopin.sym} 20 -200 2 0 {name=p12 lab=IN4}
C {iopin.sym} 20 -180 2 0 {name=p13 lab=IN5}
C {iopin.sym} 20 -160 2 0 {name=p14 lab=IN6}
C {iopin.sym} 20 -140 2 0 {name=p15 lab=IN7}
